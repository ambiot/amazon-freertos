# IAR project application_is.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 59
  General.FPU2: 0
  ICCARM.CCDefines: __thumb2__; CONFIG_PLATFORM_8710C; __ARM_ARCH_8M_MAIN__=1; CONFIG_BUILD_RAM=1; _NO_DEFINITIONS_IN_HEADER_FILES; V8M_STKOVF; __IEEE_LITTLE_ENDIAN; __ORDER_LITTLE_ENDIAN__; __BYTE_ORDER__=__ORDER_LITTLE_ENDIAN__; FILE=void
  ICCARM.IExtraOptions: --cmse; --no_path_in_file_macros
  ICCARM.CCIncludePath2: inc; ..\..\..\..\lib\third_party\realtek\component\soc\realtek\8710c\cmsis\rtl8710c\include; ..\..\..\..\lib\third_party\realtek\component\soc\realtek\8710c\cmsis\rtl8710c\lib\include; ..\..\..\..\lib\third_party\realtek\component\soc\realtek\8710c\fwlib\include; ..\..\..\..\lib\third_party\realtek\component\soc\realtek\8710c\fwlib\lib\include; ..\..\..\..\lib\third_party\realtek\component\soc\realtek\8710c\cmsis\cmsis-core\include; ..\..\..\..\lib\third_party\realtek\component\soc\realtek\8710c\cmsis\rtl8710c\include; ..\..\..\..\lib\third_party\realtek\component\soc\realtek\8710c\app\rtl_printf\include; ..\..\..\..\lib\third_party\realtek\component\soc\realtek\8710c\app\shell; ..\..\..\..\lib\third_party\realtek\component\soc\realtek\8710c\app\stdio_port; ..\..\..\..\lib\third_party\realtek\component\soc\realtek\8710c\misc\utilities\include; ..\..\..\..\lib\third_party\realtek\component\os\freertos; ..\..\..\..\lib\third_party\realtek\component\os\freertos\freertos_v10.0.1\Source\include; ..\..\..\..\lib\third_party\realtek\component\os\freertos\freertos_v10.0.1\Source\portable\IAR\ARM_RTL8710C; ..\..\..\..\lib\third_party\realtek\component\common\api; ..\..\..\..\lib\third_party\realtek\component\common\api\at_cmd; ..\..\..\..\lib\third_party\realtek\component\common\api\platform; ..\..\..\..\lib\third_party\realtek\component\common\api\wifi; ..\..\..\..\lib\third_party\realtek\component\common\api\network\include; ..\..\..\..\lib\third_party\realtek\component\common\application; ..\..\..\..\lib\third_party\realtek\component\common\application\mqtt\MQTTClient; ..\..\..\..\lib\third_party\realtek\component\common\example; ..\..\..\..\lib\third_party\realtek\component\common\file_system; ..\..\..\..\lib\third_party\realtek\component\common\file_system\dct; ..\..\..\..\lib\third_party\realtek\component\common\utilities; ..\..\..\..\lib\third_party\realtek\component\common\mbed\hal; ..\..\..\..\lib\third_party\realtek\component\common\mbed\hal_ext; ..\..\..\..\lib\third_party\realtek\component\common\mbed\targets\hal\rtl8710c; ..\..\..\..\lib\third_party\realtek\component\soc\realtek\8710c\mbed-drivers\include; ..\..\..\..\lib\third_party\realtek\component\os\os_dep\include; ..\..\..\..\lib\third_party\realtek\component\common\network; ..\..\..\..\lib\third_party\realtek\component\common\network\coap\include; ..\..\..\..\lib\third_party\realtek\component\common\network\http2\nghttp2-1.31.0\includes; ..\..\..\..\lib\third_party\lwip\src\include; ..\..\..\..\lib\third_party\lwip\src\include\lwip; ..\..\..\..\lib\third_party\lwip\src\portable\realtek; ..\..\..\..\lib\third_party\lwip\src\portable\realtek\freertos; ..\..\..\..\lib\third_party\realtek\component\common\api\wifi\rtw_wpa_supplicant\src; ..\..\..\..\lib\third_party\realtek\component\common\network\ssl\ssl_ram_map\rom; ..\..\..\..\lib\third_party\realtek\component\common\drivers\wlan\realtek\include; ..\..\..\..\lib\third_party\realtek\component\common\drivers\wlan\realtek\src\osdep; ..\..\..\..\lib\third_party\realtek\component\common\mbed\targets\hal\rtl8710c; ..\..\..\..\lib\third_party\realtek\component\common\test; ..\..\..\..\lib\third_party\realtek\component\common\bluetooth\realtek\sdk; ..\..\..\..\lib\third_party\realtek\component\common\bluetooth\realtek\sdk\inc; ..\..\..\..\lib\third_party\realtek\component\common\bluetooth\realtek\sdk\inc\app; ..\..\..\..\lib\third_party\realtek\component\common\bluetooth\realtek\sdk\inc\bluetooth\gap; ..\..\..\..\lib\third_party\realtek\component\common\bluetooth\realtek\sdk\inc\bluetooth\profile; ..\..\..\..\lib\third_party\realtek\component\common\bluetooth\realtek\sdk\inc\bluetooth\profile\server; ..\..\..\..\lib\third_party\realtek\component\common\bluetooth\realtek\sdk\inc\bluetooth\profile\client; ..\..\..\..\lib\third_party\realtek\component\common\bluetooth\realtek\sdk\inc\os; ..\..\..\..\lib\third_party\realtek\component\common\bluetooth\realtek\sdk\inc\platform; ..\..\..\..\lib\third_party\realtek\component\common\bluetooth\realtek\sdk\inc\stack; ..\..\..\..\lib\third_party\realtek\component\common\bluetooth\realtek\sdk\board\amebaz2\lib; ..\..\..\..\lib\third_party\realtek\component\common\bluetooth\realtek\sdk\board\amebaz2\src; ..\..\..\..\lib\third_party\realtek\component\common\bluetooth\realtek\sdk\board\amebaz2\src\data_uart; ..\..\..\..\lib\third_party\realtek\component\common\bluetooth\realtek\sdk\board\amebaz2\src\hci; ..\..\..\..\lib\third_party\realtek\component\common\bluetooth\realtek\sdk\board\amebaz2\src\os; ..\..\..\..\lib\third_party\realtek\component\common\bluetooth\realtek\sdk\src\mcu\module\data_uart_cmd; ..\..\..\..\lib\third_party\realtek\component\soc\realtek\8710c\misc\platform; ..\..\..\..\lib\third_party\realtek\component\common\bluetooth\realtek\sdk\board\common\inc; ..\..\..\..\lib\third_party\realtek\component\soc\realtek\8710c\misc\driver; ..\..\..\..\lib\third_party\realtek\component\soc\realtek\8710c\misc\os; ..\..\..\..\lib\third_party\mbedtls\include; ..\..\..\..\lib\include; ..\..\..\..\lib\include\private; ..\..\..\..\demos\realtek\amebaz2\common\config_files; ..\..\..\..\lib\third_party\mbedtls\include; ..\..\..\..\demos\common\include; ..\..\..\..\lib\third_party\jsmn; ..\..\..\..\lib\third_party\tinycbor; ..\..\..\..\lib\ota\portable\realtek\ameba; ..\..\..\..\lib\third_party\pkcs11; ..\..\..\..\lib\FreeRTOS-Plus-TCP\include; ..\..\..\..\lib\FreeRTOS-Plus-TCP\source\portable\Compiler\IAR; ..\..\..\..\lib\FreeRTOS-Plus-TCP\source\protocols\include; ..\..\..\..\lib\third_party\unity\extras\fixture\src; ..\..\..\..\lib\third_party\unity\src
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 2
  AARM.ADefines: V8M_STKOVF
  AARM.AUserIncludes: inc; ..\..\..\..\lib\third_party\realtek\component\soc\realtek\8710c\cmsis; ..\..\..\..\lib\third_party\realtek\component\os\os_dep\include; ..\..\..\..\lib\third_party\realtek\component\os\freertos\freertos_v10.0.1\Source\include; ..\..\..\..\lib\third_party\realtek\component\os\freertos\freertos_v10.0.1\Source\portable\IAR\ARM_RTL8710C
  OBJCOPY.OOCOutputFile: application_is.srec
  prebuild: CSCRIPT  "..\..\..\..\lib\third_party\realtek\component\soc\realtek\8710c\misc\iar_utility\prebuild.vbs" "$PROJ_DIR$"
  postbuild: CSCRIPT  "..\..\..\..\lib\third_party\realtek\component\soc\realtek\8710c\misc\iar_utility\postbuild_is.vbs" "$TARGET_DIR$" "$PROJ_DIR$" "$CONFIG_NAME$" "$TOOLKIT_DIR$"
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkKeepSymbols: ram_start
  ILINK.IlinkIcfFile: application_is.icf
  ILINK.IlinkExtraOptions: --redirect malloc=__wrap_malloc; --redirect realloc=__wrap_realloc; --redirect free=__wrap_free; --redirect printf=__wrap_printf; --redirect sprintf=__wrap_sprintf; --redirect snprintf=__wrap_snprintf; --redirect vsnprintf=__wrap_vsnprintf; --redirect memcmp=__wrap_memcmp; --redirect memcpy=__wrap_memcpy; --redirect memmove=__wrap_memmove; --redirect memset=__wrap_memset; --redirect strcat=__wrap_strcat; --redirect strchr=__wrap_strchr; --redirect strcmp=__wrap_strcmp; --redirect strncmp=__wrap_strncmp; --redirect strnicmp=__wrap_strnicmp; --redirect strcpy=__wrap_strcpy; --redirect strncpy=__wrap_strncpy; --redirect strlcpy=__wrap_strlcpy; --redirect strlen=__wrap_strlen; --redirect strnlen=__wrap_strnlen; --redirect strncat=__wrap_strncat; --redirect strpbrk=__wrap_strpbrk; --redirect strspn=__wrap_strspn; --redirect strstr=__wrap_strstr; --redirect strtok=__wrap_strtok; --redirect strxfrm=__wrap_strxfrm; --redirect strsep=__wrap_strsep; --redirect strtod=__wrap_strtod; --redirect strtof=__wrap_strtof; --redirect strtold=__wrap_strtold; --redirect strtoll=__wrap_strtoll; --redirect strtoul=__wrap_strtoul; --redirect strtoull=__wrap_strtoull; --redirect atoi=__wrap_atoi; --redirect atoui=__wrap_atoui; --redirect atol=__wrap_atol; --redirect atoul=__wrap_atoul; --redirect atoull=__wrap_atoull; --redirect atof=__wrap_atof; --skip_dynamic_initialization
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group @SRAM
    ../../../../lib/third_party/realtek/component/common/mbed/targets/hal/rtl8710c/: flash_api.c power_mode_api.c
    ../../../../lib/third_party/realtek/component/soc/realtek/8710c/misc/driver/: flash_api_ext.c
    ../../../../lib/third_party/realtek/component/common/file_system/fatfs/disk_if/src/: flash_fatfs.c
    ../../../../lib/third_party/realtek/component/soc/realtek/8710c/fwlib/source/ram_ns/: hal_flash.c hal_spic.c
  group amazon/demos
    ../common/application_code/: aws_main.c
  group amazon/demos/common/demo_runner
    ../../../common/demo_runner/: aws_demo_runner.c
    ../../../common/mqtt/: aws_subscribe_publish_loop.c
  group amazon/demos/common/devmode_key_provisioning
    ../../../common/devmode_key_provisioning/: aws_dev_mode_key_provisioning.c
  group amazon/demos/common/greengrass_connectivity
    ../../../common/greengrass_connectivity/: aws_greengrass_discovery_demo.c
  group amazon/demos/common/logging
    ../../../common/logging/: aws_logging_task_dynamic_buffers.c
  group amazon/demos/common/mqtt
    ../../../common/mqtt/: aws_hello_world.c
  group amazon/demos/common/ota
    ../../../common/ota/: aws_ota_update_demo.c
  group amazon/demos/common/shadow
    ../../../common/shadow/: aws_shadow_lightbulb_on_off.c
  group amazon/demos/common/tcp
    ../../../common/tcp/: aws_simple_tcp_echo_server.c aws_tcp_echo_client_separate_tasks.c aws_tcp_echo_client_single_task.c
  group amazon/lib/bufferpool
    ../../../../lib/bufferpool/: aws_bufferpool_static_thread_safe.c
  group amazon/lib/crypto
    ../../../../lib/crypto/: aws_crypto.c
  group amazon/lib/greengrass
    ../../../../lib/greengrass/: aws_greengrass_discovery.c aws_helper_secure_connect.c
  group amazon/lib/mqtt
    ../../../../lib/mqtt/: aws_mqtt_agent.c aws_mqtt_lib.c
  group amazon/lib/ota
    ../../../../lib/ota/: aws_ota_agent.c aws_ota_cbor.c
  group amazon/lib/ota/portable
    ../../../../lib/ota/portable/realtek/ameba/: aws_ota_pal.c aws_ota_rtl8710b.c
  group amazon/lib/pkcs11/mbedtls
    ../../../../lib/pkcs11/mbedtls/: aws_pkcs11_mbedtls.c
  group amazon/lib/pkcs11/portable
    ../../../../lib/pkcs11/portable/realtek/ameba/: aws_pkcs11_pal.c
  group amazon/lib/secure_sockets
    ../../../../lib/secure_sockets/portable/realtek/ameba/: aws_secure_sockets.c
  group amazon/lib/shadow
    ../../../../lib/shadow/: aws_shadow.c aws_shadow_json.c
  group amazon/lib/third_party/jsmn
    ../../../../lib/third_party/jsmn/: jsmn.c
  group amazon/lib/third_party/mbedtls
    ../../../../lib/third_party/mbedtls/library/: aes.c aesni.c arc4.c asn1parse.c asn1write.c base64.c bignum.c blowfish.c camellia.c ccm.c certs.c cipher.c cipher_wrap.c cmac.c ctr_drbg.c debug.c des.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c entropy.c entropy_poll.c error.c gcm.c havege.c hmac_drbg.c md.c md2.c md4.c md5.c md_wrap.c memory_buffer_alloc.c net_sockets.c oid.c padlock.c pem.c pk.c pk_wrap.c pkcs12.c pkcs5.c pkparse.c pkwrite.c platform.c platform_util.c ripemd160.c rsa.c rsa_internal.c sha1.c sha256.c sha512.c ssl_cache.c ssl_ciphersuites.c ssl_cli.c ssl_cookie.c ssl_srv.c ssl_ticket.c ssl_tls.c threading.c timing.c version.c version_features.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509write_crt.c x509write_csr.c xtea.c
  group amazon/lib/third_party/tinycbor
    ../../../../lib/third_party/tinycbor/: cborencoder.c cborencoder_close_container_checked.c cborerrorstrings.c cborparser.c cborparser_dup_string.c cborpretty.c
  group amazon/lib/third_party/unity
    ../../../../lib/third_party/unity/src/: unity.c
    ../../../../lib/third_party/unity/extras/fixture/src/: unity_fixture.c
  group amazon/lib/tls
    ../../../../lib/tls/: aws_tls.c
  group amazon/lib/utils
    ../../../../lib/utils/: aws_system_init.c
  group amazon/lib/wifi
    ../../../../lib/wifi/portable/realtek/ameba/: aws_wifi.c
  group bluetooth/board
    ../../../../lib/third_party/realtek/component/common/bluetooth/realtek/sdk/board/amebaz2/src/hci/: bt_fwconfig.c hci_board.c hci_uart.c
    ../../../../lib/third_party/realtek/component/common/bluetooth/realtek/sdk/board/common/src/: cycle_queue.c
    ../../../../lib/third_party/realtek/component/common/bluetooth/realtek/sdk/board/amebaz2/src/data_uart/: data_uart.c
    ../../../../lib/third_party/realtek/component/common/file_system/ftl/: ftl.c
    ../../../../lib/third_party/realtek/component/common/bluetooth/realtek/sdk/board/common/os/freertos_v10.0.1_IAR/: osif_freertos.c
    ../../../../lib/third_party/realtek/component/common/bluetooth/realtek/sdk/board/amebaz2/src/: platform_utils.c rtk_coex.c trace_uart.c
  group bluetooth/common
    ../../../../lib/third_party/realtek/component/common/bluetooth/realtek/sdk/src/ble/profile/client/: ancs_client.c bas_client.c gaps_client.c simple_ble_client.c
    ../../../../lib/third_party/realtek/component/common/bluetooth/realtek/sdk/src/ble/profile/server/: bas.c dis.c hids.c hids_kb.c hids_rmc.c simple_ble_service.c
    ../../../../lib/third_party/realtek/component/common/bluetooth/realtek/sdk/board/common/src/: bt_uart_bridge.c hci_adapter.c hci_process.c trace_task.c
  group bluetooth/example
    ../../../../lib/third_party/realtek/component/common/bluetooth/realtek/sdk/: bt_example_entry.c
  group bluetooth/example/ble_peripheral
    ../../../../lib/third_party/realtek/component/common/bluetooth/realtek/sdk/example/ble_peripheral/: app_task.c ble_app_main.c peripheral_app.c
  group bluetooth/example/bt_beacon
    ../../../../lib/third_party/realtek/component/common/bluetooth/realtek/sdk/example/bt_beacon/: bt_beacon_app.c bt_beacon_app_main.c bt_beacon_app_task.c
  group bluetooth/example/bt_config
    ../../../../lib/third_party/realtek/component/common/bluetooth/realtek/sdk/example/bt_config/: bt_config_app_main.c bt_config_app_task.c bt_config_peripheral_app.c bt_config_service.c bt_config_wifi.c
  group cmsis
    ../../../../lib/third_party/realtek/component/soc/realtek/8710c/cmsis/rtl8710c/source/ram_s/: app_start.c
    ../../../../lib/third_party/realtek/component/soc/realtek/8710c/misc/utilities/source/ram/: libc_wrap.c
    ../../../../lib/third_party/realtek/component/soc/realtek/8710c/cmsis/rtl8710c/source/ram/: mpu_config.c
  group console
    ../../../../lib/third_party/realtek/component/common/api/at_cmd/: atcmd_bt.c atcmd_isp.c atcmd_lwip.c atcmd_media.c atcmd_mp.c atcmd_mp_ext2.c atcmd_sys.c atcmd_wifi.c log_service.c
    ../../../../lib/third_party/realtek/component/soc/realtek/8710c/app/shell/: cmd_shell.c
    ../../../../lib/third_party/realtek/component/soc/realtek/8710c/app/shell/ram_s/: consol_cmds.c
    ../../../../lib/third_party/realtek/component/soc/realtek/8710c/misc/driver/: low_level_io.c rtl_console.c
  group lib
    ../../../../lib/third_party/realtek/component/common/bluetooth/realtek/sdk/board/amebaz2/lib/: btgap.a
    ../../../../lib/third_party/realtek/component/soc/realtek/8710c/fwlib/lib/lib/: hal_pmc.a
    ../../../../lib/third_party/realtek/component/soc/realtek/8710c/misc/bsp/lib/common/IAR/: lib_dct.a lib_eap.a lib_googlenest.a lib_http.a lib_p2p.a lib_soc_is.a lib_websocket.a lib_wlan.a lib_wps.a
  group network/api
    ../../../../lib/third_party/realtek/component/common/api/: lwip_netconf.c
  group network/api/wifi
    ../../../../lib/third_party/realtek/component/common/api/wifi/: wifi_conf.c wifi_ind.c wifi_promisc.c wifi_simple_config.c wifi_util.c
  group network/api/wifi/rtw_wpa_supplicant
    ../../../../lib/third_party/realtek/component/common/api/wifi/rtw_wpa_supplicant/src/crypto/: tls_polarssl.c
    ../../../../lib/third_party/realtek/component/common/api/wifi/rtw_wpa_supplicant/wpa_supplicant/: wifi_eap_config.c wifi_p2p_config.c wifi_wps_config.c
  group network/app
    ../../../../lib/third_party/realtek/component/soc/realtek/8710c/misc/platform/: ota_8710c.c
    ../../../../lib/third_party/realtek/component/common/api/network/src/: ping_test.c wlan_network.c
    ../../../../lib/third_party/realtek/component/common/utilities/: ssl_client.c ssl_client_ext.c tcptest.c
  group network/app/mqtt
    ../../../../lib/third_party/realtek/component/common/application/mqtt/MQTTClient/: MQTTClient.c MQTTFreertos.c
    ../../../../lib/third_party/realtek/component/common/application/mqtt/MQTTPacket/: MQTTConnectClient.c MQTTConnectServer.c MQTTDeserializePublish.c MQTTFormat.c MQTTPacket.c MQTTSerializePublish.c MQTTSubscribeClient.c MQTTSubscribeServer.c MQTTUnsubscribeClient.c MQTTUnsubscribeServer.c
  group network/coap
    ../../../../lib/third_party/realtek/component/common/network/coap/: sn_coap_ameba_port.c sn_coap_builder.c sn_coap_header_check.c sn_coap_parser.c sn_coap_protocol.c
  group network/googlenest
    ../../../../lib/third_party/realtek/component/common/application/google/: google_tls.c
  group network/http
    ../../../../lib/third_party/realtek/component/common/network/httpc/: httpc_tls.c
    ../../../../lib/third_party/realtek/component/common/network/httpd/: httpd_tls.c
  group network/lwip
    ../../../../lib/third_party/realtek/component/common/network/dhcp/: dhcps.c
    ../../../../lib/third_party/realtek/component/common/network/sntp/: sntp.c
  group network/lwip/api
    ../../../../lib/third_party/lwip/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group network/lwip/core
    ../../../../lib/third_party/lwip/src/core/: def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
  group network/lwip/core/ipv4
    ../../../../lib/third_party/lwip/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
  group network/lwip/core/ipv6
    ../../../../lib/third_party/lwip/src/core/ipv6/: dhcp6.c ethip6.c icmp6.c inet6.c ip6.c ip6_addr.c ip6_frag.c mld6.c nd6.c
  group network/lwip/netif
    ../../../../lib/third_party/lwip/src/netif/: ethernet.c
  group network/lwip/port
    ../../../../lib/third_party/lwip/src/portable/realtek/freertos/: ethernetif.c sys_arch.c
    ../../../../lib/third_party/realtek/component/common/drivers/wlan/realtek/src/osdep/: lwip_intf.c
  group network/mdns
    ../../../../lib/third_party/realtek/component/common/network/mDNS/: mDNSPlatform.c
  group network/ssl/mbedtls
    ../../../../lib/third_party/realtek/component/common/network/ssl/mbedtls-2.4.0/library/: aesni.c blowfish.c camellia.c ccm.c certs.c cipher.c cipher_wrap.c cmac.c debug.c error.c gcm.c havege.c md2.c md4.c memory_buffer_alloc.c net_sockets.c padlock.c pkcs11.c pkcs12.c pkcs5.c pkparse.c platform.c ripemd160.c ssl_cache.c ssl_ciphersuites.c ssl_cli.c ssl_cookie.c ssl_srv.c ssl_ticket.c ssl_tls.c threading.c timing.c version.c version_features.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509write_crt.c x509write_csr.c xtea.c
  group network/ssl/ssl_ram_map
    ../../../../lib/third_party/realtek/component/common/network/ssl/ssl_ram_map/rom/: rom_ssl_ram_map.c
    ../../../../lib/third_party/realtek/component/common/network/ssl/ssl_func_stubs/: ssl_func_stubs.c
  group network/websocket
    ../../../../lib/third_party/realtek/component/common/network/websocket/: wsclient_tls.c wsserver_tls.c
  group os
    ../../../../lib/third_party/realtek/component/os/freertos/: cmsis_os.c freertos_cb.c freertos_service.c
    ../../../../lib/third_party/realtek/component/os/os_dep/: device_lock.c osdep_service.c
  group os/freertos
    ../../../../lib/third_party/realtek/component/os/freertos/freertos_v10.0.1/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group os/freertos/portable
    ../../../../lib/third_party/realtek/component/os/freertos/freertos_v10.0.1/Source/portable/MemMang/: heap_5.c
    ../../../../lib/third_party/realtek/component/os/freertos/freertos_v10.0.1/Source/portable/IAR/ARM_RTL8710C/: port.c portasm.s
  group peripheral/api
    ../../../../lib/third_party/realtek/component/common/mbed/targets/hal/rtl8710c/: crypto_api.c dma_api.c efuse_api.c gpio_api.c gpio_irq_api.c i2c_api.c pinmap.c pinmap_common.c port_api.c pwmout_api.c serial_api.c spdio_api.c spi_api.c sys_api.c timer_api.c us_ticker.c us_ticker_api.c wait_api.c wdt_api.c
  group peripheral/hal
    ../../../../lib/third_party/realtek/component/soc/realtek/8710c/fwlib/source/ram_s/: hal_efuse.c hal_pinmux_nsc.c
    ../../../../lib/third_party/realtek/component/soc/realtek/8710c/fwlib/source/ram/: hal_gdma.c hal_gpio.c hal_misc.c hal_uart.c
    ../../../../lib/third_party/realtek/component/soc/realtek/8710c/fwlib/source/ram_ns/: hal_i2c.c hal_pwm.c hal_sdio_dev.c hal_ssi.c
  group peripheral/wlan
    ../../../../lib/third_party/realtek/component/common/drivers/wlan/realtek/src/core/option/: rtw_opt_power_by_rate.c rtw_opt_power_limit.c rtw_opt_skbuf.c
  group user
    src/: main.c
  group utilities
    ../../../../lib/third_party/realtek/component/common/utilities/: cJSON.c http_client.c xml.c
  group utilities/example
    ../../../../lib/third_party/realtek/component/common/example/amazon_awsiot/: example_amazon_awsiot.c
    ../../../../lib/third_party/realtek/component/common/example/amazon_freertos/: example_amazon_freertos.c
    ../../../../lib/third_party/realtek/component/common/example/bcast/: example_bcast.c
    ../../../../lib/third_party/realtek/component/common/example/cJSON/: example_cJSON.c
    ../../../../lib/third_party/realtek/component/common/example/coap/: example_coap.c
    ../../../../lib/third_party/realtek/component/common/example/dct/: example_dct.c
    ../../../../lib/third_party/realtek/component/common/example/eap/: example_eap.c
    ../../../../lib/third_party/realtek/component/common/example/: example_entry.c
    ../../../../lib/third_party/realtek/component/common/example/get_beacon_frame/: example_get_beacon_frame.c
    ../../../../lib/third_party/realtek/component/common/example/googlenest/: example_google.c
    ../../../../lib/third_party/realtek/component/common/example/high_load_memory_use/: example_high_load_memory_use.c
    ../../../../lib/third_party/realtek/component/common/example/http_client/: example_http_client.c
    ../../../../lib/third_party/realtek/component/common/example/http_download/: example_http_download.c
    ../../../../lib/third_party/realtek/component/common/example/httpc/: example_httpc.c
    ../../../../lib/third_party/realtek/component/common/example/httpd/: example_httpd.c
    ../../../../lib/third_party/realtek/component/common/example/ipv6/: example_ipv6.c
    ../../../../lib/third_party/realtek/component/common/example/mcast/: example_mcast.c
    ../../../../lib/third_party/realtek/component/common/example/mqtt/: example_mqtt.c
    ../../../../lib/third_party/realtek/component/common/example/nonblock_connect/: example_nonblock_connect.c
    ../../../../lib/third_party/realtek/component/common/example/ota_http/: example_ota_http.c
    ../../../../lib/third_party/realtek/component/common/example/rarp/: example_rarp.c
    ../../../../lib/third_party/realtek/component/common/example/secure_boot/: example_secure_boot.c
    ../../../../lib/third_party/realtek/component/common/example/sntp_showtime/: example_sntp_showtime.c
    ../../../../lib/third_party/realtek/component/common/example/socket_select/: example_socket_select.c
    ../../../../lib/third_party/realtek/component/common/example/socket_tcp_trx/: example_socket_tcp_trx_1.c example_socket_tcp_trx_2.c
    ../../../../lib/third_party/realtek/component/common/example/ssl_download/: example_ssl_download.c
    ../../../../lib/third_party/realtek/component/common/example/ssl_server/: example_ssl_server.c
    ../../../../lib/third_party/realtek/component/common/example/tcp_keepalive/: example_tcp_keepalive.c
    ../../../../lib/third_party/realtek/component/common/example/uart_atcmd/: example_uart_atcmd.c
    ../../../../lib/third_party/realtek/component/common/example/wifi_mac_monitor/: example_wifi_mac_monitor.c
    ../../../../lib/third_party/realtek/component/common/example/wifi_roaming/: example_wifi_roaming.c
    ../../../../lib/third_party/realtek/component/common/example/wlan_fast_connect/: example_wlan_fast_connect.c
    ../../../../lib/third_party/realtek/component/common/example/wlan_scenario/: example_wlan_scenario.c
    ../../../../lib/third_party/realtek/component/common/example/websocket_client/: example_wsclient.c
    ../../../../lib/third_party/realtek/component/common/example/xml/: example_xml.c
  group utilities/FatFs/disk_if
    ../../../../lib/third_party/realtek/component/common/file_system/fatfs/disk_if/src/: sdcard.c usbdisk.c
    ../../../../lib/third_party/realtek/component/common/drivers/sdio/realtek/sdio_host/src/: sdio_combine.c
  group utilities/FatFs/fatfs_ext
    ../../../../lib/third_party/realtek/component/common/file_system/fatfs/fatfs_ext/src/: ff_driver.c
  group utilities/FatFs/r0.10c
    ../../../../lib/third_party/realtek/component/common/file_system/fatfs/r0.10c/src/: diskio.c ff.c
  group utilities/FatFs/r0.10c/option
    ../../../../lib/third_party/realtek/component/common/file_system/fatfs/r0.10c/src/option/: ccsbcs.c
