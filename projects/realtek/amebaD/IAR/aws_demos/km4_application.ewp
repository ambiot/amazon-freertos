# IAR project km4_application.ewp, settings and files
configuration is (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 59
  General.FPU2: 6
  ICCARM.CCDefines: CONFIG_PLATFORM_8721D; __FPU_PRESENT; CONFIG_USE_MBEDTLS_ROM_ALG; CONFIG_FUNCION_O0_OPTIMIZE; DM_ODM_SUPPORT_TYPE=32; __IEEE_LITTLE_ENDIAN
  ICCARM.IExtraOptions: --no_path_in_file_macros; --cmse
  ICCARM.CCIncludePath2: ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\os\; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\os\freertos; ..\..\..\..\..\freertos_kernel\include; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\os\freertos\freertos_v10.2.0\Source\portable\IAR\RTL8721D_HP\non_secure; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\os\freertos\freertos_v10.2.0\Source\portable\IAR\RTL8721D_HP\secure; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\soc\realtek\amebad\cmsis\; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\soc\realtek\amebad\cmsis\device; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\soc\realtek\amebad\fwlib\include; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\soc\realtek\amebad\fwlib\rom_map_hp; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\soc\realtek\amebad\app\monitor\include; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\soc\realtek\amebad\app\xmodem; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\soc\realtek\amebad\swlib\include; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\soc\realtek\amebad\swlib\string; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\soc\realtek\amebad\misc; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\soc\realtek\amebad\swlib\os_dep\include\; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\soc\realtek\amebad\swlib\os_dep\..\; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\soc\realtek\amebad\swlib\string; ..\..\..\..\..\vendors\realtek\sdk\amebaD\inc\inc_hp; ..\..\..\..\..\vendors\realtek\boards\amebaD\aws_demos\config_files; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\api; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\api\platform; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\api\wifi; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\api\network; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\api\network\include; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\audio; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\test; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\example; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\utilities; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\drivers\si; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\audio\haac; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\audio\hmp3; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\audio\fdk-aac; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\audio\libav; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\audio\fdk-aac\libSYS\include; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\drivers\wlan\realtek\include; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\drivers\wlan\realtek\src\hci; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\drivers\wlan\realtek\src\osdep; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\drivers\wlan\realtek\src\hal; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\drivers\wlan\realtek\src\hal\phydm; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\drivers\wlan\realtek\src\hal\rtl8721d; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\drivers\wlan\realtek\src\hal\rtl8721d\little_driver\include; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\drivers\wlan\realtek\wlan_ram_map\rom; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\network; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\network\lwip\lwip_v2.0.2\src\include; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\network\lwip\lwip_v2.0.2\src\include\lwip; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\network\lwip\lwip_v2.0.2\src\include\netif; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\network\lwip\lwip_v2.0.2\port\realtek; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\network\lwip\lwip_v2.0.2\port\realtek\freertos; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\api; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\api\at_cmd; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\api\wifi\rtw_wpa_supplicant\src; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\os\os_dep\include\; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\drivers\inic\rtl8721d; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\network\ssl\polarssl-1.3.8\include; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\network\ssl\ssl_ram_map\rom; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\network\ssl\mbedtls_ram_map\rom; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\mbed\targets\hal\rtl8721d\; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\mbed\targets\hal\rtl8721d\include; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\mbed\api; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\mbed\hal; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\mbed\hal_ext; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\application\baidu\libduer-device\external\mbedtls-port; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\application\apple\WACServer\External\Curve25519; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\application\apple\WACServer\External\GladmanAES; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\application\apple\homekit\crypto\chacha; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\application\apple\homekit\crypto\poly1305; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\application\apple\homekit\crypto\ed25519; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\application\apple\homekit\crypto\ed25519\core; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\application\apple\homekit\crypto\sha512; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\file_system\fatfs\r0.10c\include; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\file_system\fatfs; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\file_system\ftl; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\application\baidu\libduer-device\framework\core; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\application\baidu\libduer-device\framework\include; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\application\baidu\duerapp\include; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\bluetooth\realtek\sdk\inc\os; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\bluetooth\realtek\sdk\inc\bluetooth\gap; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\bluetooth\realtek\sdk\board\amebad\lib; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\bluetooth\realtek\sdk\inc\app; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\bluetooth\realtek\sdk\inc\platform; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\bluetooth\realtek\sdk\inc\bluetooth\profile; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\bluetooth\realtek\sdk\example\ble_central; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\bluetooth\realtek\sdk\example\ble_scatternet; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\bluetooth\realtek\sdk\inc\bluetooth\profile\client; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\bluetooth\realtek\sdk\board\common\inc; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\bluetooth\realtek\sdk\inc\bluetooth\profile\server; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\bluetooth\realtek\sdk\src\mcu\module\data_uart_cmd; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\bluetooth\realtek\sdk\inc\stack; $TOOLKIT_DIR$\inc\c; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\network\coap\include; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\drivers\sdio\realtek\sdio_host\inc; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\bluetooth\realtek\sdk\example\bt_config; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\bluetooth\realtek\sdk\example\bt_airsync_config; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\application\airsync\1.0.4; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\bluetooth\realtek\sdk\board\common\inc; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\bluetooth\realtek\sdk\board\amebad\src\vendor_cmd; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\bluetooth\realtek\sdk\board\amebad\src\hci; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\bluetooth\realtek\sdk\board\amebad\src; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\bluetooth\realtek\sdk\inc; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\bluetooth\realtek\sdk; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\drivers\wlan\realtek\src\core\option; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\api\wifi\rtw_wpa_supplicant\src\crypto; ..\..\..\..\..\vendors\realtek\sdk\amebaD\src\src_hp; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\drivers\ir\protocol; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\ui\emwin\emWinLibrary\include; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\ui\emwin\Sample\rtl8721d\Config; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\ui\emwin\Sample\rtl8721d\hal; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\ui\emwin\Third_Party\truetype; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\drivers\ir\protocol; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\example\amazon_freertos; ..\..\..\..\..\vendors\realtek\boards\amebaD\aws_demos\config_files; ..\..\..\..\..\demos\include; ..\..\..\..\..\demos\network_manager; ..\..\..\..\..\demos\dev_mode_key_provisioning\include; ..\..\..\..\..\libraries\abstractions\pkcs11\include; ..\..\..\..\..\libraries\abstractions\pkcs11\mbedtls; ..\..\..\..\..\libraries\abstractions\platform\include; ..\..\..\..\..\libraries\abstractions\platform\freertos\include; ..\..\..\..\..\libraries\abstractions\platform\freertos\include\platform; ..\..\..\..\..\libraries\abstractions\secure_sockets\include; ..\..\..\..\..\libraries\abstractions\wifi\include; ..\..\..\..\..\libraries\c_sdk\standard\common\include; ..\..\..\..\..\libraries\c_sdk\standard\common\include\private; ..\..\..\..\..\libraries\c_sdk\standard\mqtt\include; ..\..\..\..\..\libraries\c_sdk\standard\mqtt\src\private; ..\..\..\..\..\libraries\freertos_plus\aws\ota\include; ..\..\..\..\..\libraries\freertos_plus\aws\ota\src; ..\..\..\..\..\libraries\freertos_plus\aws\ota\src\mqtt; ..\..\..\..\..\vendors\realtek\boards\amebaD\libraries\freertos_plus\standard\crypto\include; ..\..\..\..\..\libraries\freertos_plus\standard\pkcs11\include; ..\..\..\..\..\libraries\freertos_plus\standard\tls\include; ..\..\..\..\..\libraries\freertos_plus\standard\utils\include; ..\..\..\..\..\libraries\3rdparty\jsmn; ..\..\..\..\..\libraries\3rdparty\mbedtls\include; ..\..\..\..\..\libraries\3rdparty\mbedtls\include\mbedtls; ..\..\..\..\..\libraries\3rdparty\tinycbor; ..\..\..\..\..\libraries\3rdparty\unity\src; ..\..\..\..\..\libraries\3rdparty\unity\extras\fixture\src; ..\..\..\..\..\libraries\3rdparty\pkcs11; ..\..\..\..\..\freertos_kernel\include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: CONFIG_PLATFORM_8721D; __FPU_PRESENT; CONFIG_USE_MBEDTLS_ROM_ALG; CONFIG_FUNCION_O0_OPTIMIZE; DM_ODM_SUPPORT_TYPE=32
  AARM.AUserIncludes: ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\os\freertos\freertos_v10.2.0\Source\portable\IAR\RTL8721D_HP\non_secure; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\os\freertos\freertos_v10.2.0\Source\portable\IAR\RTL8721D_HP\secure; ..\..\..\..\..\vendors\realtek\sdk\amebaD\inc\inc_hp; ..\..\..\..\..\vendors\realtek\boards\amebaD\aws_demos\config_files
  OBJCOPY.OOCOutputFile: km4_application.srec
  prebuild: CSCRIPT  "..\..\..\..\..\vendors\realtek\sdk\amebaD\component\soc\realtek\amebad\misc\iar_utility\common\rtl8721d_prebuild.vbs" "$PROJ_DIR$" "..\..\..\..\..\vendors\realtek\sdk\amebaD\inc\inc_hp"
  postbuild: CSCRIPT  "..\..\..\..\..\vendors\realtek\sdk\amebaD\component\soc\realtek\amebad\misc\iar_utility\common\rtl8721dhp_postbuild_img2.vbs" "$TARGET_DIR$" "$PROJ_DIR$" "$TOOLKIT_DIR$" "normal"
  ILINK.IlinkOutputFile: km4_application.axf
  ILINK.IlinkIcfFile: rtl8721dhp_image2_is.icf
  ILINK.IlinkExtraOptions: --redirect aesccmp_construct_mic_iv=aesccmp_construct_mic_iv_ram; --redirect aesccmp_construct_mic_header1=aesccmp_construct_mic_header1_ram; --redirect aesccmp_construct_ctr_preload=aesccmp_construct_ctr_preload_ram; --redirect rom_psk_CalcGTK=ram_patch_rom_psk_CalcGTK; --redirect rom_psk_CalcPTK=ram_patch_rom_psk_CalcPTK; --redirect aes_80211_encrypt=ram_patch_aes_80211_encrypt; --redirect aes_80211_decrypt=ram_patch_aes_80211_decrypt
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration is (mp) (ARM, debug)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  ICCARM.CCDefines: CONFIG_PLATFORM_8721D; __FPU_PRESENT; CONFIG_USE_MBEDTLS_ROM_ALG; CONFIG_FUNCION_O0_OPTIMIZE; DM_ODM_SUPPORT_TYPE=32; CONFIG_MP_INCLUDED; CONFIG_BT_MP
  ICCARM.CCIncludePath2: ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\os\; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\os\freertos; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\os\freertos\freertos_v10.2.0\Source\include\; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\os\freertos\freertos_v10.2.0\Source\portable\IAR\RTL8721D_HP\non_secure; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\os\freertos\freertos_v10.2.0\Source\portable\IAR\RTL8721D_HP\secure; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\soc\realtek\amebad\cmsis\; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\soc\realtek\amebad\cmsis\device; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\soc\realtek\amebad\fwlib\include; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\soc\realtek\amebad\fwlib\rom_map_hp; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\soc\realtek\amebad\app\monitor\include; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\soc\realtek\amebad\app\xmodem; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\soc\realtek\amebad\swlib\include; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\soc\realtek\amebad\swlib\string; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\soc\realtek\amebad\misc; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\soc\realtek\amebad\swlib\os_dep\include\; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\soc\realtek\amebad\swlib\os_dep\..\; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\soc\realtek\amebad\swlib\string; ..\..\..\..\..\vendors\realtek\sdk\amebaD\inc\inc_hp; ..\..\..\..\..\vendors\realtek\boards\amebaD\aws_demos\config_files; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\api; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\api\platform; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\api\wifi; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\api\network; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\api\network\include; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\audio; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\test; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\example; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\utilities; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\drivers\si; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\audio\haac; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\audio\hmp3; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\audio\fdk-aac; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\audio\libav; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\audio\fdk-aac\libSYS\include; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\drivers\wlan\realtek\include; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\drivers\wlan\realtek\src\hci; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\drivers\wlan\realtek\src\osdep; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\drivers\wlan\realtek\src\hal; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\drivers\wlan\realtek\src\hal\phydm; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\drivers\wlan\realtek\src\hal\rtl8721d; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\drivers\wlan\realtek\src\hal\rtl8721d\little_driver\include; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\drivers\wlan\realtek\wlan_ram_map\rom; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\network; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\network\lwip\lwip_v2.0.2\src\include; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\network\lwip\lwip_v2.0.2\src\include\lwip; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\network\lwip\lwip_v2.0.2\src\include\netif; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\network\lwip\lwip_v2.0.2\port\realtek; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\network\lwip\lwip_v2.0.2\port\realtek\freertos; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\api; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\api\at_cmd; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\api\wifi\rtw_wpa_supplicant\src; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\os\os_dep\include\; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\drivers\inic\rtl8721d; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\network\ssl\polarssl-1.3.8\include; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\network\ssl\ssl_ram_map\rom; ..\..\..\..\..\libraries\3rdparty\mbedtls\include; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\network\ssl\mbedtls_ram_map\rom; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\mbed\targets\hal\rtl8721d\; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\mbed\targets\hal\rtl8721d\include; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\mbed\api; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\mbed\hal; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\mbed\hal_ext; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\application\baidu\libduer-device\external\mbedtls-port; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\application\apple\WACServer\External\Curve25519; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\application\apple\WACServer\External\GladmanAES; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\application\apple\homekit\crypto\chacha; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\application\apple\homekit\crypto\poly1305; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\application\apple\homekit\crypto\ed25519; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\application\apple\homekit\crypto\ed25519\core; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\application\apple\homekit\crypto\sha512; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\file_system\fatfs\r0.10c\include; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\file_system\fatfs; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\file_system\ftl; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\application\baidu\libduer-device\framework\core; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\application\baidu\libduer-device\framework\include; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\application\baidu\duerapp\include; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\bluetooth\realtek\sdk\inc\os; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\bluetooth\realtek\sdk\inc\bluetooth\gap; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\bluetooth\realtek\sdk\board\amebad\lib; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\bluetooth\realtek\sdk\inc\app; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\bluetooth\realtek\sdk\inc\platform; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\bluetooth\realtek\sdk\inc\bluetooth\profile; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\bluetooth\realtek\sdk\example\ble_central; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\bluetooth\realtek\sdk\example\ble_scatternet; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\bluetooth\realtek\sdk\inc\bluetooth\profile\client; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\bluetooth\realtek\sdk\board\common\inc; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\bluetooth\realtek\sdk\inc\bluetooth\profile\server; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\bluetooth\realtek\sdk\src\mcu\module\data_uart_cmd; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\bluetooth\realtek\sdk\inc\stack; $TOOLKIT_DIR$\inc\c; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\network\coap\include; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\drivers\sdio\realtek\sdio_host\inc; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\bluetooth\realtek\sdk\example\bt_config; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\bluetooth\realtek\sdk\example\bt_airsync_config; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\application\airsync\1.0.4; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\bluetooth\realtek\sdk\board\common\inc; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\bluetooth\realtek\sdk\board\amebad\src\vendor_cmd; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\bluetooth\realtek\sdk\board\amebad\src\hci; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\bluetooth\realtek\sdk\board\amebad\src; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\bluetooth\realtek\sdk\inc; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\bluetooth\realtek\sdk; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\drivers\wlan\realtek\src\core\option; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\api\wifi\rtw_wpa_supplicant\src\crypto; ..\..\..\..\..\libraries\abstractions\pkcs11\mbedtls; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\ui\emwin\emWinLibrary\include; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\ui\emwin\Sample\rtl8721d\Config; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\ui\emwin\Sample\rtl8721d\hal; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\ui\emwin\Third_Party\truetype
  AARM.ADefines: as above
  postbuild: CSCRIPT  "..\..\..\..\..\vendors\realtek\sdk\amebaD\component\soc\realtek\amebad\misc\iar_utility\common\rtl8721dhp_postbuild_img2.vbs" "$TARGET_DIR$" "$PROJ_DIR$" "$TOOLKIT_DIR$" "mp"
configuration tz (ARM, debug)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  ICCARM.CCDefines: CONFIG_PLATFORM_8721D; __FPU_PRESENT; CONFIG_USE_MBEDTLS_ROM_ALG; CONFIG_FUNCION_O0_OPTIMIZE; DM_ODM_SUPPORT_TYPE=32; CONFIG_TRUSTZONE_EN=1; CONFIG_BUILD_NONSECURE=1
  ICCARM.CCIncludePath2: as above
  AARM.ADefines: CONFIG_PLATFORM_8721D; __FPU_PRESENT; CONFIG_USE_MBEDTLS_ROM_ALG; CONFIG_FUNCION_O0_OPTIMIZE; DM_ODM_SUPPORT_TYPE=32; CONFIG_TRUSTZONE_EN=1
  ILINK.IlinkIcfFile: rtl8721dhp_image2_tz.icf
configuration tz (mp) (ARM, debug)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  ICCARM.CCDefines: CONFIG_PLATFORM_8721D; __FPU_PRESENT; CONFIG_USE_MBEDTLS_ROM_ALG; CONFIG_FUNCION_O0_OPTIMIZE; DM_ODM_SUPPORT_TYPE=32; CONFIG_TRUSTZONE_EN=1; CONFIG_BUILD_NONSECURE=1; CONFIG_MP_INCLUDED; CONFIG_BT_MP
  ICCARM.CCIncludePath2: as above
  AARM.ADefines: CONFIG_PLATFORM_8721D; __FPU_PRESENT; CONFIG_USE_MBEDTLS_ROM_ALG; CONFIG_FUNCION_O0_OPTIMIZE; DM_ODM_SUPPORT_TYPE=32; CONFIG_TRUSTZONE_EN=1; CONFIG_MP_INCLUDED; CONFIG_BT_MP
  postbuild: as above
  ILINK.IlinkIcfFile: rtl8721dhp_image2_tz.icf
  group @SRAM/network/lwip/port
    ../../../../../vendors/realtek/sdk/amebaD/component/common/network/lwip/lwip_v2.0.2/port/realtek/freertos/: ethernetif.c sys_arch.c
    ../../../../../vendors/realtek/sdk/amebaD/component/common/drivers/wlan/realtek/src/osdep/: lwip_intf.c
  group @SRAM/network/lwip/src/api
    ../../../../../vendors/realtek/sdk/amebaD/component/common/network/lwip/lwip_v2.0.2/src/api/: api_lib.c api_msg.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group @SRAM/network/lwip/src/core
    ../../../../../vendors/realtek/sdk/amebaD/component/common/network/lwip/lwip_v2.0.2/src/core/: def.c inet_chksum.c ip.c mem.c memp.c netif.c pbuf.c raw.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../../../../../vendors/realtek/sdk/amebaD/component/common/network/lwip/lwip_v2.0.2/src/core/ipv4/: etharp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    ../../../../../vendors/realtek/sdk/amebaD/component/common/network/lwip/lwip_v2.0.2/src/core/ipv6/: ethip6.c ip6.c ip6_addr.c ip6_frag.c
  group @SRAM/network/lwip/src/netif
    ../../../../../vendors/realtek/sdk/amebaD/component/common/network/lwip/lwip_v2.0.2/src/netif/: ethernet.c
  group @SRAM/os/freertos
    ../../../../../vendors/realtek/sdk/amebaD/component/os/freertos/: cmsis_os.c freertos_backtrace_ext.c freertos_cb.c freertos_heap5_config.c freertos_service.c
  group @SRAM/os/freertos/source/portable
    ../../../../../vendors/realtek/sdk/amebaD/component/os/freertos/freertos_v10.2.0/Source/portable/IAR/RTL8721D_HP/non_secure/: port.c portasm.s
  group @SRAM/os/freertos/source/v10.2.0
    ../../../../../vendors/realtek/sdk/amebaD/component/os/freertos/freertos_v10.2.0/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../../../../../vendors/realtek/sdk/amebaD/component/os/freertos/freertos_v10.2.0/Source/portable/MemMang/: heap_5.c
  group @SRAM/os/freertos/source/v10.3.0
    ../../../../../freertos_kernel/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../../../../../freertos_kernel/portable/MemMang/: heap_5.c
  group @SRAM/os/os_dep
    ../../../../../vendors/realtek/sdk/amebaD/component/os/os_dep/: device_lock.c osdep_service.c psram_reserve.c
  group amazon/demos
    ../../../../../demos/dev_mode_key_provisioning/src/: aws_dev_mode_key_provisioning.c
    ../../../../../demos/ota/: aws_iot_ota_update_demo.c
    ../../../../../demos/coreMQTT/: mqtt_demo_mutual_auth.c
    ../../../../../demos/device_shadow_for_aws/: shadow_demo_main.c
  group amazon/demos/common/mqtt_demo_helpers
    ../../../../../demos/common/mqtt_demo_helpers/: mqtt_demo_helpers.c
  group amazon/demos/common/pkcs11_helpers
    ../../../../../demos/common/pkcs11_helpers/: pkcs11_helpers.c
  group amazon/demos/demo_runner
    ../../../../../demos/demo_runner/: aws_demo.c aws_demo_network_addr.c aws_demo_version.c iot_demo_freertos.c iot_demo_runner.c
  group amazon/demos/network_manager
    ../../../../../demos/network_manager/: aws_iot_demo_network.c aws_iot_network_manager.c
  group amazon/libraries/3rdparty/jsmn
    ../../../../../libraries/3rdparty/jsmn/: jsmn.c
  group amazon/libraries/3rdparty/mbedtls/library
    ../../../../../libraries/3rdparty/mbedtls/library/: aes.c aesni.c arc4.c aria.c asn1parse.c asn1write.c base64.c bignum.c blowfish.c camellia.c ccm.c certs.c chacha20.c chachapoly.c cipher.c cipher_wrap.c cmac.c ctr_drbg.c debug.c des.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c entropy.c entropy_poll.c error.c gcm.c havege.c hkdf.c hmac_drbg.c md.c md2.c md4.c md5.c md_wrap.c memory_buffer_alloc.c net_sockets.c nist_kw.c oid.c padlock.c pem.c pk.c pk_wrap.c pkcs11.c pkcs12.c pkcs5.c pkparse.c pkwrite.c platform.c platform_util.c poly1305.c ripemd160.c rsa.c rsa_internal.c sha1.c sha256.c sha512.c ssl_cache.c ssl_ciphersuites.c ssl_cli.c ssl_cookie.c ssl_srv.c ssl_ticket.c ssl_tls.c threading.c timing.c version.c version_features.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509write_crt.c x509write_csr.c xtea.c
  group amazon/libraries/3rdparty/mbedtls_utils
    ../../../../../libraries/3rdparty/mbedtls_utils/: mbedtls_error.c mbedtls_utils.c
  group amazon/libraries/3rdparty/tinycbor
    ../../../../../libraries/3rdparty/tinycbor/src/: cborencoder.c cborencoder_close_container_checked.c cborerrorstrings.c cborparser.c cborparser_dup_string.c cborpretty.c cborvalidation.c
  group amazon/libraries/3rdparty/unity
    ../../../../../libraries/3rdparty/unity/src/: unity.c
    ../../../../../libraries/3rdparty/unity/extras/fixture/src/: unity_fixture.c
  group amazon/libraries/abstractions/backoff_algorithm
    ../../../../../libraries/abstractions/backoff_algorithm/source/: backoff_algorithm.c
  group amazon/libraries/abstractions/pkcs11
    ../../../../../vendors/realtek/boards/amebaD/libraries/abstractions/pkcs11/mbedtls/: iot_pkcs11_mbedtls.c
  group amazon/libraries/abstractions/pkcs11/corePKCS11
    ../../../../../libraries/abstractions/pkcs11/corePKCS11/source/: core_pkcs11.c core_pki_utils.c
  group amazon/libraries/abstractions/pkcs11/corePKCS11/portable/mbedtls
    ../../../../../libraries/abstractions/pkcs11/corePKCS11/source/portable/mbedtls/: core_pkcs11_mbedtls.c
  group amazon/libraries/abstractions/pkcs11/psa
    ../../../../../libraries/abstractions/pkcs11/psa/: iot_pkcs11_psa.c iot_pkcs11_psa_input_format.c iot_pkcs11_psa_object_management.c
  group amazon/libraries/abstractions/platform/freertos
    ../../../../../libraries/abstractions/platform/freertos/: iot_clock_freertos.c iot_metrics.c iot_network_freertos.c iot_threads_freertos.c
  group amazon/libraries/abstractions/test
    ../../../../../libraries/abstractions/pkcs11/test/: iot_test_pkcs11.c
    ../../../../../libraries/abstractions/secure_sockets/test/: iot_test_tcp.c
    ../../../../../libraries/abstractions/wifi/test/: iot_test_wifi.c
  group amazon/libraries/abstractions/transport/secure_sockets
    ../../../../../libraries/abstractions/transport/secure_sockets/: transport_secure_sockets.c
  group amazon/libraries/c_sdk/standard/common
    ../../../../../vendors/realtek/boards/amebaD/libraries/c_sdk/standard/common/: iot_device_metrics.c
    ../../../../../libraries/c_sdk/standard/common/: iot_init.c iot_static_memory_common.c
  group amazon/libraries/c_sdk/standard/common/taskpool
    ../../../../../libraries/c_sdk/standard/common/taskpool/: iot_taskpool.c iot_taskpool_static_memory.c
  group amazon/libraries/c_sdk/standard/mqtt/src
    ../../../../../libraries/c_sdk/standard/mqtt/src/: iot_mqtt_agent.c iot_mqtt_api.c iot_mqtt_context_connection.c iot_mqtt_managed_function_wrapper.c iot_mqtt_mutex_wrapper.c iot_mqtt_network.c iot_mqtt_operation.c iot_mqtt_publish_duplicates.c iot_mqtt_serializer_deserializer_wrapper.c iot_mqtt_static_memory.c iot_mqtt_subscription.c iot_mqtt_subscription_container.c iot_mqtt_validate.c
  group amazon/libraries/c_sdk/standard/test
    ../../../../../libraries/c_sdk/standard/mqtt/test/access/: iot_test_access_mqtt_api.c iot_test_access_mqtt_subscription.c
    ../../../../../libraries/c_sdk/standard/mqtt/test/: iot_test_mqtt_agent.c
    ../../../../../libraries/c_sdk/standard/mqtt/test/unit/: iot_tests_mqtt_api.c iot_tests_mqtt_metrics.c iot_tests_mqtt_receive.c iot_tests_mqtt_subscription.c iot_tests_mqtt_validate.c
    ../../../../../libraries/c_sdk/standard/mqtt/test/mock/: iot_tests_mqtt_mock.c
    ../../../../../libraries/c_sdk/standard/mqtt/test/system/: iot_tests_mqtt_system.c
  group amazon/libraries/coreHTTP
    ../../../../../libraries/coreHTTP/source/: core_http_client.c
  group amazon/libraries/coreHTTP/http_parser
    ../../../../../libraries/coreHTTP/source/dependency/3rdparty/http_parser/: http_parser.c
  group amazon/libraries/coreJSON
    ../../../../../libraries/coreJSON/source/: core_json.c
  group amazon/libraries/coreMQTT/source
    ../../../../../libraries/coreMQTT/source/: core_mqtt.c core_mqtt_serializer.c core_mqtt_state.c
  group amazon/libraries/device_shadow_for_aws
    ../../../../../libraries/device_shadow_for_aws/source/: shadow.c
  group amazon/libraries/freertos_plus/aws
    ../../../../../libraries/freertos_plus/aws/ota/src/: aws_iot_ota_agent.c aws_iot_ota_interface.c
    ../../../../../libraries/freertos_plus/aws/ota/src/mqtt/: aws_iot_ota_cbor.c aws_iot_ota_mqtt.c
  group amazon/libraries/freertos_plus/standard/crypto
    ../../../../../vendors/realtek/boards/amebaD/libraries/freertos_plus/standard/crypto/src/: iot_crypto.c
  group amazon/libraries/freertos_plus/standard/tls
    ../../../../../libraries/freertos_plus/standard/tls/src/: iot_tls.c
  group amazon/libraries/freertos_plus/standard/utils
    ../../../../../vendors/realtek/boards/amebaD/libraries/freertos_plus/standard/utils/src/: iot_system_init.c
  group amazon/libraries/freertos_plus/test
    ../../../../../libraries/freertos_plus/aws/ota/test/: aws_test_ota_agent.c aws_test_ota_cbor.c aws_test_ota_end_to_end.c aws_test_ota_pal.c
    ../../../../../libraries/freertos_plus/standard/tls/test/: iot_test_tls.c
  group amazon/libraries/logging
    ../../../../../libraries/logging/: iot_logging.c iot_logging_task_dynamic_buffers.c
  group amazon/vendor
    ../../../../../vendors/realtek/boards/amebaD/aws_demos/application_code/: aws_main.c
  group amazon/vendor/port
    ../../../../../vendors/realtek/boards/amebaD/ports/ota/: aws_ota_pal.c aws_ota_rtl8721d.c
    ../../../../../vendors/realtek/boards/amebaD/ports/pkcs11/: core_pkcs11_pal.c iot_pkcs11_pal.c
    ../../../../../vendors/realtek/boards/amebaD/ports/secure_sockets/: iot_secure_sockets.c
    ../../../../../vendors/realtek/boards/amebaD/ports/wifi/: iot_wifi.c
  group app
    ../../../../../vendors/realtek/sdk/amebaD/component/soc/realtek/amebad/app/touch_key/: touch_key.c
  group app/monitor
    ../../../../../vendors/realtek/sdk/amebaD/component/soc/realtek/amebad/app/monitor/ram/: low_level_io.c monitor_hp.c rtl_trace.c shell_ram.c
    ../../../../../vendors/realtek/sdk/amebaD/component/soc/realtek/amebad/app/monitor/rom/: monitor_rom.c shell_rom.c
  group cmsis-dsp
    ../../../../../vendors/realtek/sdk/amebaD/component/soc/realtek/amebad/cmsis-dsp/Source/BasicMathFunctions/: arm_abs_f32.c arm_abs_q15.c arm_abs_q31.c arm_abs_q7.c arm_add_f32.c arm_add_q15.c arm_add_q31.c arm_add_q7.c arm_dot_prod_f32.c arm_dot_prod_q15.c arm_dot_prod_q31.c arm_dot_prod_q7.c arm_mult_f32.c arm_mult_q15.c arm_mult_q31.c arm_mult_q7.c arm_negate_f32.c arm_negate_q15.c arm_negate_q31.c arm_negate_q7.c arm_offset_f32.c arm_offset_q15.c arm_offset_q31.c arm_offset_q7.c arm_scale_f32.c arm_scale_q15.c arm_scale_q31.c arm_scale_q7.c arm_shift_q15.c arm_shift_q31.c arm_shift_q7.c arm_sub_f32.c arm_sub_q15.c arm_sub_q31.c arm_sub_q7.c
    ../../../../../vendors/realtek/sdk/amebaD/component/soc/realtek/amebad/cmsis-dsp/Source/TransformFunctions/: arm_bitreversal.c arm_bitreversal2.S arm_cfft_f32.c arm_cfft_q15.c arm_cfft_q31.c arm_cfft_radix2_f32.c arm_cfft_radix2_init_f32.c arm_cfft_radix2_init_q15.c arm_cfft_radix2_init_q31.c arm_cfft_radix2_q15.c arm_cfft_radix2_q31.c arm_cfft_radix4_f32.c arm_cfft_radix4_init_f32.c arm_cfft_radix4_init_q15.c arm_cfft_radix4_init_q31.c arm_cfft_radix4_q15.c arm_cfft_radix4_q31.c arm_cfft_radix8_f32.c arm_dct4_f32.c arm_dct4_init_f32.c arm_dct4_init_q15.c arm_dct4_init_q31.c arm_dct4_q15.c arm_dct4_q31.c arm_rfft_f32.c arm_rfft_fast_f32.c arm_rfft_fast_init_f32.c arm_rfft_init_f32.c arm_rfft_init_q15.c arm_rfft_init_q31.c
    ../../../../../vendors/realtek/sdk/amebaD/component/soc/realtek/amebad/cmsis-dsp/Source/ComplexMathFunctions/: arm_cmplx_conj_f32.c arm_cmplx_conj_q15.c arm_cmplx_conj_q31.c arm_cmplx_dot_prod_f32.c arm_cmplx_dot_prod_q15.c arm_cmplx_dot_prod_q31.c arm_cmplx_mag_f32.c arm_cmplx_mag_q15.c arm_cmplx_mag_q31.c arm_cmplx_mag_squared_f32.c arm_cmplx_mag_squared_q15.c arm_cmplx_mag_squared_q31.c arm_cmplx_mult_cmplx_f32.c arm_cmplx_mult_cmplx_q15.c arm_cmplx_mult_cmplx_q31.c arm_cmplx_mult_real_f32.c arm_cmplx_mult_real_q15.c arm_cmplx_mult_real_q31.c
    ../../../../../vendors/realtek/sdk/amebaD/component/soc/realtek/amebad/cmsis-dsp/Source/CommonTables/: arm_common_tables.c arm_const_structs.c
    ../../../../../vendors/realtek/sdk/amebaD/component/soc/realtek/amebad/cmsis-dsp/Source/FastMathFunctions/: arm_cos_f32.c arm_cos_q15.c arm_cos_q31.c arm_sin_f32.c arm_sin_q15.c arm_sin_q31.c arm_sqrt_q15.c arm_sqrt_q31.c
  group fwlib
    ../../../../../vendors/realtek/sdk/amebaD/component/soc/realtek/amebad/fwlib/ram_common/: rtl8721d_adc.c rtl8721d_bor.c rtl8721d_captouch.c rtl8721d_comparator.c rtl8721d_flash_ram.c rtl8721d_gdma_memcpy.c rtl8721d_i2c.c rtl8721d_ipc_api.c rtl8721d_ir.c rtl8721d_keyscan.c rtl8721d_pll.c rtl8721d_ram_libc.c rtl8721d_rand2.c rtl8721d_rtc.c rtl8721d_sgpio.c rtl8721d_tim.c rtl8721d_uart.c rtl8721d_wdg.c
    ../../../../../vendors/realtek/sdk/amebaD/component/soc/realtek/amebad/fwlib/crypto/: rtl8721dhp_aes_ram.c rtl8721dhp_chacha_poly1305.c rtl8721dhp_crypto_ram.c rtl8721dhp_des_ram.c rtl8721dhp_md5.c rtl8721dhp_sha.c
    ../../../../../vendors/realtek/sdk/amebaD/component/soc/realtek/amebad/fwlib/ram_hp/: rtl8721dhp_app_start.c rtl8721dhp_audio.c rtl8721dhp_clk.c rtl8721dhp_cpft.c rtl8721dhp_i2s.c rtl8721dhp_lcdc.c rtl8721dhp_ota_ram.c rtl8721dhp_pmc.c rtl8721dhp_pmc_ram.c rtl8721dhp_psram.c rtl8721dhp_sd.c rtl8721dhp_sdio.c rtl8721dhp_sdio_host.c rtl8721dhp_simulation.c rtl8721dhp_ssi.c rtl8721dhp_startup.c rtl8721dhp_system.c rtl8721dhp_usi_i2c.c rtl8721dhp_usi_ssi.c rtl8721dhp_usi_uart.c
  group fwlib/usrcfg
    ../../../../../vendors/realtek/sdk/amebaD/component/soc/realtek/amebad/fwlib/usrcfg/: rtl8721d_ipccfg.c rtl8721d_wificfg.c rtl8721dhp_intfcfg.c rtl8721dlp_intfcfg.c
  group lib
    ../../../../../vendors/realtek/sdk/amebaD/component/soc/realtek/amebad/misc/bsp/lib/common/IAR/: lib_wlan.a lib_wps.a
  group mbed
    ../../../../../vendors/realtek/sdk/amebaD/component/common/mbed/targets/hal/rtl8721d/: flash_api.c gpio_api.c rtc_api.c sys_api.c timer_api.c wait_api.c wdt_api.c
  group misc
    ../../../../../vendors/realtek/sdk/amebaD/component/soc/realtek/amebad/misc/: rtl8721d_freertos_pmu.c rtl8721d_ota.c
  group user
    ../../../../../vendors/realtek/sdk/amebaD/src/src_hp/: main.c
  group utilities/example
    ../../../../../vendors/realtek/sdk/amebaD/component/common/example/amazon_freertos/: example_amazon_freertos.c
    ../../../../../vendors/realtek/sdk/amebaD/component/common/example/: example_entry.c
  group wifi/api
    ../../../../../vendors/realtek/sdk/amebaD/component/common/api/at_cmd/: atcmd_sys.c atcmd_wifi.c log_service.c
    ../../../../../vendors/realtek/sdk/amebaD/component/common/api/: lwip_netconf.c
    ../../../../../vendors/realtek/sdk/amebaD/component/common/api/network/src/: ping_test.c wlan_network.c
    ../../../../../vendors/realtek/sdk/amebaD/component/common/api/wifi/: wifi_conf.c wifi_ind.c wifi_promisc.c wifi_util.c
    ../../../../../vendors/realtek/sdk/amebaD/component/common/api/wifi/rtw_wpa_supplicant/wpa_supplicant/: wifi_eap_config.c
  group wifi/network
    ../../../../../vendors/realtek/sdk/amebaD/component/common/network/dhcp/: dhcps.c
  group wifi/network/lwip/api
    ../../../../../vendors/realtek/sdk/amebaD/component/common/network/lwip/lwip_v2.0.2/src/api/: err.c
  group wifi/network/lwip/core
    ../../../../../vendors/realtek/sdk/amebaD/component/common/network/lwip/lwip_v2.0.2/src/core/ipv4/: autoip.c dhcp.c icmp.c
    ../../../../../vendors/realtek/sdk/amebaD/component/common/network/lwip/lwip_v2.0.2/src/core/ipv6/: dhcp6.c icmp6.c inet6.c mld6.c nd6.c
    ../../../../../vendors/realtek/sdk/amebaD/component/common/network/lwip/lwip_v2.0.2/src/core/: dns.c init.c stats.c sys.c
