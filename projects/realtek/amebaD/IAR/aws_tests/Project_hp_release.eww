<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\km4_application.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\km4_bootloader.ewp</path>
    </project>
    <batchBuild />
</workspace>
