# IAR project km0_application.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 58
  General.FPU2: 0
  ICCARM.CCDefines: CONFIG_PLATFORM_8721D; MBEDTLS_CONFIG_FILE="aws_mbedtls_config.h"; __ARM_FEATURE_DSP=0
  ICCARM.IExtraOptions: --no_path_in_file_macros
  ICCARM.CCIncludePath2: ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\soc\realtek\amebad\fwlib\include; ..\..\..\..\..\vendors\realtek\sdk\amebaD\inc\inc_lp; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\soc\realtek\amebad\swlib\string; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\soc\realtek\amebad\swlib\include; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\soc\realtek\amebad\app\monitor\include; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\soc\realtek\amebad\app\touch_key; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\os\freertos; ..\..\..\..\..\freertos_kernel\include; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\os\freertos\freertos_v10.4.3\Source\portable\IAR\RTL8721D_LP; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\soc\realtek\amebad\cmsis; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\soc\realtek\amebad\wifi_fw\include; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\soc\realtek\amebad\app\monitor\include; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\soc\realtek\amebad\app\xmodem; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\soc\realtek\amebad\swlib\include; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\soc\realtek\amebad\swlib\string; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\soc\realtek\amebad\misc; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\api; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\api\wifi; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\api\network; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\api\network\include; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\test; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\example; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\utilities; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\drivers\wlan\realtek\include; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\drivers\wlan\realtek\src\hci; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\drivers\wlan\realtek\src\osdep; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\drivers\wlan\realtek\src\hal; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\drivers\wlan\realtek\src\hal\OUTSRC; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\drivers\wlan\realtek\src\hal\rtl8721d; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\drivers\wlan\realtek\wlan_ram_map\rom; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\network; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\network\lwip\lwip_v2.0.2\src\include; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\network\lwip\lwip_v2.0.2\src\include\lwip; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\network\lwip\lwip_v2.0.2\src\include\netif; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\network\lwip\lwip_v2.0.2\port\realtek; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\network\lwip\lwip_v2.0.2\port\realtek\freertos; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\api; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\api\at_cmd; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\api\wifi\rtw_wpa_supplicant\src; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\os\os_dep\include\; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\network\ssl\polarssl-1.3.8\include; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\network\ssl\ssl_ram_map\rom; ..\..\..\..\..\libraries\3rdparty\mbedtls\include; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\network\ssl\ssl_ram_map\rom; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\mbed\targets\hal\rtl8721d\; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\application\apple\WACServer\External\Curve25519; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\application\apple\WACServer\External\GladmanAES; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\application\apple\homekit\crypto\chacha; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\application\apple\homekit\crypto\poly1305; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\application\apple\homekit\crypto\ed25519; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\application\apple\homekit\crypto\ed25519\core; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\application\apple\homekit\crypto\sha512; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\api\platform; ..\..\..\..\..\libraries\abstractions\pkcs11\mbedtls; ..\..\..\..\..\libraries\3rdparty\mbedtls_config
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\..\..\..\..\vendors\realtek\sdk\amebaD\inc\inc_lp; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\os\freertos\freertos_v10.4.3\Source\portable\IAR\RTL8721D_LP
  OBJCOPY.OOCOutputFile: km0_application.srec
  prebuild: CSCRIPT  "..\..\..\..\..\vendors\realtek\sdk\amebaD\component\soc\realtek\amebad\misc\iar_utility\common\rtl8721d_prebuild.vbs" "$PROJ_DIR$" "..\..\..\..\..\vendors\realtek\sdk\amebaD\inc\inc_lp"
  postbuild: CSCRIPT  "..\..\..\..\..\vendors\realtek\sdk\amebaD\component\soc\realtek\amebad\misc\iar_utility\common\rtl8721dlp_postbuild_img2.vbs" "$TARGET_DIR$" "$PROJ_DIR$" "$TOOLKIT_DIR$"
  ILINK.IlinkOutputFile: km0_application.axf
  ILINK.IlinkIcfFile: rtl8721dlp_image2.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptStrategy: 0
  group app
    ../../../../../vendors/realtek/sdk/amebaD/component/soc/realtek/amebad/app/touch_key/: touch_key.c
  group console
    ../../../../../vendors/realtek/sdk/amebaD/component/soc/realtek/amebad/app/monitor/ram/: monitor_lp.c rtl_trace.c shell_ram.c
  group fwlib
    ../../../../../vendors/realtek/sdk/amebaD/component/soc/realtek/amebad/fwlib/ram_common/: rtl8721d_adc.c rtl8721d_bor.c rtl8721d_captouch.c rtl8721d_comparator.c rtl8721d_efuse.c rtl8721d_flash_ram.c rtl8721d_i2c.c rtl8721d_ipc_api.c rtl8721d_keyscan.c rtl8721d_pll.c rtl8721d_qdec.c rtl8721d_rtc.c rtl8721d_sgpio.c rtl8721d_tim.c rtl8721d_uart.c rtl8721d_wdg.c
    ../../../../../vendors/realtek/sdk/amebaD/component/soc/realtek/amebad/fwlib/usrcfg/: rtl8721d_ipccfg.c rtl8721d_wificfg.c rtl8721dlp_flashcfg.c rtl8721dlp_intfcfg.c rtl8721dlp_pinmapcfg.c rtl8721dlp_sleepcfg.c
    ../../../../../vendors/realtek/sdk/amebaD/component/soc/realtek/amebad/fwlib/ram_lp/: rtl8721dlp_app_start.c rtl8721dlp_clk.c rtl8721dlp_cpft.c rtl8721dlp_flashclk.c rtl8721dlp_km4.c rtl8721dlp_pinmap.c rtl8721dlp_pmc.c rtl8721dlp_pmc_ram.c rtl8721dlp_simulation.c rtl8721dlp_startup.c rtl8721dlp_system.c
  group lib
    ../../../../../vendors/realtek/sdk/amebaD/component/soc/realtek/amebad/misc/bsp/lib/common/IAR/: lib_wifi_fw.a
  group misc
    ../../../../../vendors/realtek/sdk/amebaD/component/soc/realtek/amebad/misc/: rtl8721d_freertos_pmu.c
  group os/freertos
    ../../../../../vendors/realtek/sdk/amebaD/component/os/freertos/: freertos_backtrace_ext.c freertos_heap5_config.c
  group os/freertos/source/portable
    ../../../../../vendors/realtek/sdk/amebaD/component/os/freertos/freertos_v10.4.3/Source/portable/IAR/RTL8721D_LP/: port.c portasm.s
  group os/freertos/source/v10.2.0
    ../../../../../vendors/realtek/sdk/amebaD/component/os/freertos/freertos_v10.2.0/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../../../../../vendors/realtek/sdk/amebaD/component/os/freertos/freertos_v10.2.0/Source/portable/MemMang/: heap_5.c
  group os/freertos/source/v10.4.3
    ../../../../../freertos_kernel/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../../../../../freertos_kernel/portable/MemMang/: heap_5.c
  group user
    ../../../../../vendors/realtek/sdk/amebaD/src/src_lp/: main.c
