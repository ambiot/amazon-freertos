# IAR project km0_bootloader.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 58
  General.FPU2: 0
  ICCARM.CCDefines: CONFIG_PLATFORM_8721D; MBEDTLS_CONFIG_FILE="aws_mbedtls_config.h"; MBEDTLS_CONFIG_FILE="aws_mbedtls_config.h"
  ICCARM.IExtraOptions: --no_path_in_file_macros
  ICCARM.CCIncludePath2: ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\soc\realtek\amebad\fwlib\include; ..\..\..\..\..\vendors\realtek\sdk\amebaD\inc\inc_lp; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\soc\realtek\amebad\swlib\string; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\soc\realtek\amebad\swlib\include; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\soc\realtek\amebad\app\monitor\include; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\os\freertos; ..\..\..\..\..\freertos_kernel\include; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\os\freertos\freertos_v10.2.0\Source\portable\IAR\RTL8721D_LP; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\soc\realtek\amebad\cmsis; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\soc\realtek\amebad\wifi_fw\include; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\soc\realtek\amebad\app\monitor\include; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\soc\realtek\amebad\app\xmodem; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\soc\realtek\amebad\swlib\include; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\soc\realtek\amebad\swlib\string; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\soc\realtek\amebad\misc; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\api; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\api\wifi; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\api\network; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\api\network\include; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\test; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\example; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\utilities; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\drivers\wlan\realtek\include; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\drivers\wlan\realtek\src\hci; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\drivers\wlan\realtek\src\osdep; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\drivers\wlan\realtek\src\hal; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\drivers\wlan\realtek\src\hal\OUTSRC; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\drivers\wlan\realtek\src\hal\rtl8721d; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\drivers\wlan\realtek\wlan_ram_map\rom; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\network; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\network\lwip\lwip_v1.4.1\src\include; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\network\lwip\lwip_v1.4.1\src\include\lwip; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\network\lwip\lwip_v1.4.1\src\include\netif; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\network\lwip\lwip_v1.4.1\src\include\ipv4; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\network\lwip\lwip_v1.4.1\port\realtek; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\network\lwip\lwip_v1.4.1\port\realtek\freertos; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\api; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\api\platform; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\api\at_cmd; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\api\wifi\rtw_wpa_supplicant\src; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\os\os_dep\include\; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\network\ssl\polarssl-1.3.8\include; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\network\ssl\ssl_ram_map\rom; ..\..\..\..\..\libraries\3rdparty\mbedtls\include; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\network\ssl\ssl_ram_map\rom; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\mbed\targets\hal\rtl8721d\; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\application\apple\WACServer\External\Curve25519; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\application\apple\WACServer\External\GladmanAES; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\application\apple\homekit\crypto\chacha; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\application\apple\homekit\crypto\poly1305; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\application\apple\homekit\crypto\ed25519; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\application\apple\homekit\crypto\ed25519\core; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\application\apple\homekit\crypto\sha512; ..\..\..\..\..\libraries\abstractions\pkcs11\mbedtls; ..\..\..\..\..\libraries\3rdparty\mbedtls_config
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: km0_bootloader.srec
  prebuild: CSCRIPT  "..\..\..\..\..\vendors\realtek\sdk\amebaD\component\soc\realtek\amebad\misc\iar_utility\common\rtl8721d_prebuild.vbs" "$PROJ_DIR$" "..\..\..\..\..\vendors\realtek\sdk\amebaD\inc\inc_lp"
  postbuild: CSCRIPT  "..\..\..\..\..\vendors\realtek\sdk\amebaD\component\soc\realtek\amebad\misc\iar_utility\common\rtl8721dlp_postbuild_img1.vbs" "$TARGET_DIR$" "$PROJ_DIR$" "$TOOLKIT_DIR$"
  ILINK.IlinkOutputFile: km0_bootloader.axf
  ILINK.IlinkIcfFile: rtl8721dlp_bootloader.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptStrategy: 0
  group cmsis
    ../../../../../vendors/realtek/sdk/amebaD/component/soc/realtek/amebad/bootloader/: boot_flash_lp.c boot_ram_lp.c
    ../../../../../vendors/realtek/sdk/amebaD/component/soc/realtek/amebad/fwlib/usrcfg/: rtl8721d_bootcfg.c
    ../../../../../vendors/realtek/sdk/amebaD/component/soc/realtek/amebad/fwlib/ram_lp/: rtl8721dlp_clk.c
