# IAR project km4_bootloader.ewp, settings and files
configuration is (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 59
  General.FPU2: 6
  ICCARM.CCDefines: CONFIG_PLATFORM_8721D; MBEDTLS_CONFIG_FILE="aws_mbedtls_config.h"
  ICCARM.IExtraOptions: --no_path_in_file_macros
  ICCARM.CCIncludePath2: ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\os; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\os\freertos; ..\..\..\..\..\freertos_kernel\include; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\os\freertos\freertos_v10.2.0\Source\portable\IAR\RTL8721D_HP\non_secure\; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\soc\realtek\amebad\cmsis\; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\soc\realtek\amebad\cmsis\device; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\soc\realtek\amebad\fwlib\include; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\soc\realtek\amebad\fwlib\rom_map_hp; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\soc\realtek\amebad\app\monitor\include; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\soc\realtek\amebad\app\xmodem; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\soc\realtek\amebad\swlib\include; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\soc\realtek\amebad\swlib\string; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\soc\realtek\amebad\misc; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\soc\realtek\amebad\swlib\os_dep\include\; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\soc\realtek\amebad\swlib\os_dep\..\; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\soc\realtek\amebad\swlib\string; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\api; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\api\platform; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\api\wifi; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\api\network; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\api\network\include; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\audio; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\test; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\example; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\utilities; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\drivers\si; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\audio\haac; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\audio\hmp3; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\audio\fdk-aac; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\audio\libav; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\audio\fdk-aac\libSYS\include; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\drivers\wlan\realtek\include; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\drivers\wlan\realtek\src\hci; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\drivers\wlan\realtek\src\osdep; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\drivers\wlan\realtek\src\hal; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\drivers\wlan\realtek\src\hal\phydm; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\drivers\wlan\realtek\src\hal\rtl8721d; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\drivers\wlan\realtek\wlan_ram_map\rom; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\network; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\network\lwip\lwip_v2.0.2\src\include; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\network\lwip\lwip_v2.0.2\src\include\lwip; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\network\lwip\lwip_v2.0.2\src\include\netif; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\network\lwip\lwip_v2.0.2\port\realtek; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\network\lwip\lwip_v2.0.2\port\realtek\freertos; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\api; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\api\at_cmd; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\api\wifi\rtw_wpa_supplicant\src; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\os\os_dep\include\; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\drivers\inic\rtl8721d; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\network\ssl\polarssl-1.3.8\include; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\network\ssl\ssl_ram_map\rom; ..\..\..\..\..\libraries\3rdparty\mbedtls\include; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\network\ssl\mbedtls_ram_map\rom; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\mbed\targets\hal\rtl8721d\; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\mbed\targets\hal\rtl8721d\include; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\application\baidu\libduer-device\external\mbedtls-port; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\application\apple\WACServer\External\Curve25519; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\application\apple\WACServer\External\GladmanAES; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\application\apple\homekit\crypto\chacha; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\application\apple\homekit\crypto\poly1305; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\application\apple\homekit\crypto\ed25519; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\application\apple\homekit\crypto\ed25519\core; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\application\apple\homekit\crypto\sha512; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\file_system\fatfs\r0.10c\include; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\file_system\fatfs; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\application\baidu\libduer-device\framework\core; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\application\baidu\libduer-device\framework\include; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\application\baidu\duerapp\include; ..\..\..\..\..\vendors\realtek\sdk\amebaD\inc\inc_hp; ..\..\..\..\..\vendors\realtek\boards\amebaD\aws_tests\config_files; ..\..\..\..\..\libraries\abstractions\pkcs11\mbedtls; ..\..\..\..\..\libraries\3rdparty\unity\src; ..\..\..\..\..\libraries\3rdparty\unity\extras\fixture\src; ..\..\..\..\..\libraries\3rdparty\mbedtls_config
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: km4_bootloader.srec
  prebuild: CSCRIPT  "..\..\..\..\..\vendors\realtek\sdk\amebaD\component\soc\realtek\amebad\misc\iar_utility\common\rtl8721d_prebuild.vbs" "$PROJ_DIR$" "..\..\..\..\..\vendors\realtek\sdk\amebaD\inc\inc_hp"
  postbuild: CSCRIPT  "..\..\..\..\..\vendors\realtek\sdk\amebaD\component\soc\realtek\amebad\misc\iar_utility\common\rtl8721dhp_postbuild_img1.vbs" "$TARGET_DIR$" "$PROJ_DIR$" "$TOOLKIT_DIR$"
  ILINK.IlinkOutputFile: km4_bootloader.axf
  ILINK.IlinkIcfFile: rtl8721dhp_bootloader.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration tz (ARM, debug)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  ICCARM.CCDefines: CONFIG_PLATFORM_8721D; CONFIG_TRUSTZONE_EN=1
  ICCARM.CCIncludePath2: ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\os; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\os\freertos; ..\..\..\..\..\freertos_kernel\include; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\os\freertos\freertos_v10.2.0\Source\portable\IAR\RTL8721D_HP\non_secure\; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\soc\realtek\amebad\cmsis\; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\soc\realtek\amebad\cmsis\device; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\soc\realtek\amebad\fwlib\include; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\soc\realtek\amebad\fwlib\rom_map_hp; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\soc\realtek\amebad\app\monitor\include; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\soc\realtek\amebad\app\xmodem; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\soc\realtek\amebad\swlib\include; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\soc\realtek\amebad\swlib\string; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\soc\realtek\amebad\misc; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\soc\realtek\amebad\swlib\os_dep\include\; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\soc\realtek\amebad\swlib\os_dep\..\; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\soc\realtek\amebad\swlib\string; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\api; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\api\platform; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\api\wifi; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\api\network; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\api\network\include; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\audio; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\test; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\example; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\utilities; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\drivers\si; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\audio\haac; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\audio\hmp3; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\audio\fdk-aac; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\audio\libav; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\audio\fdk-aac\libSYS\include; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\drivers\wlan\realtek\include; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\drivers\wlan\realtek\src\hci; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\drivers\wlan\realtek\src\osdep; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\drivers\wlan\realtek\src\hal; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\drivers\wlan\realtek\src\hal\phydm; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\drivers\wlan\realtek\src\hal\rtl8721d; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\drivers\wlan\realtek\wlan_ram_map\rom; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\network; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\network\lwip\lwip_v2.0.2\src\include; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\network\lwip\lwip_v2.0.2\src\include\lwip; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\network\lwip\lwip_v2.0.2\src\include\netif; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\network\lwip\lwip_v2.0.2\port\realtek; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\network\lwip\lwip_v2.0.2\port\realtek\freertos; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\api; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\api\at_cmd; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\api\wifi\rtw_wpa_supplicant\src; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\os\os_dep\include\; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\drivers\inic\rtl8721d; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\network\ssl\polarssl-1.3.8\include; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\network\ssl\ssl_ram_map\rom; ..\..\..\..\..\libraries\3rdparty\mbedtls\include; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\network\ssl\mbedtls_ram_map\rom; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\mbed\targets\hal\rtl8721d\; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\mbed\targets\hal\rtl8721d\include; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\application\baidu\libduer-device\external\mbedtls-port; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\application\apple\WACServer\External\Curve25519; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\application\apple\WACServer\External\GladmanAES; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\application\apple\homekit\crypto\chacha; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\application\apple\homekit\crypto\poly1305; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\application\apple\homekit\crypto\ed25519; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\application\apple\homekit\crypto\ed25519\core; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\application\apple\homekit\crypto\sha512; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\file_system\fatfs\r0.10c\include; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\file_system\fatfs; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\application\baidu\libduer-device\framework\core; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\application\baidu\libduer-device\framework\include; ..\..\..\..\..\vendors\realtek\sdk\amebaD\component\common\application\baidu\duerapp\include; ..\..\..\..\..\vendors\realtek\sdk\amebaD\inc\inc_hp; ..\..\..\..\..\vendors\realtek\boards\amebaD\aws_tests\config_files; ..\..\..\..\..\libraries\abstractions\pkcs11\mbedtls
  group cmsis
    ../../../../../vendors/realtek/sdk/amebaD/component/soc/realtek/amebad/bootloader/: boot_flash_hp.c boot_ram_hp.c boot_trustzone_hp.c
    ../../../../../vendors/realtek/sdk/amebaD/component/soc/realtek/amebad/fwlib/usrcfg/: rtl8721d_bootcfg.c rtl8721dhp_boot_trustzonecfg.c
