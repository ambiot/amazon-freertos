# IAR project application_is.ewp, settings and files
configuration amazon_freertos (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 59
  General.FPU2: 0
  ICCARM.CCDefines: __thumb2__; CONFIG_PLATFORM_8710C; __ARM_ARCH_8M_MAIN__=1; CONFIG_BUILD_RAM=1; _NO_DEFINITIONS_IN_HEADER_FILES; V8M_STKOVF; __IEEE_LITTLE_ENDIAN; __ORDER_LITTLE_ENDIAN__; __BYTE_ORDER__=__ORDER_LITTLE_ENDIAN__; FILE=void; ENABLE_AMAZON_COMMON; MBEDTLS_CONFIG_FILE="aws_mbedtls_config.h"; UNITY_INCLUDE_CONFIG_H; AMAZON_FREERTOS_ENABLE_UNIT_TESTS
  ICCARM.IExtraOptions: --cmse; --no_path_in_file_macros
  ICCARM.CCIncludePath2: ..\..\..\..\..\vendors\realtek\sdk\amebaZ2\project\realtek_amebaz2_v0_example\inc; ..\..\..\..\..\vendors\realtek\sdk\amebaZ2\component\soc\realtek\8710c\cmsis\rtl8710c\include; ..\..\..\..\..\vendors\realtek\sdk\amebaZ2\component\soc\realtek\8710c\cmsis\rtl8710c\lib\include; ..\..\..\..\..\vendors\realtek\sdk\amebaZ2\component\soc\realtek\8710c\fwlib\include; ..\..\..\..\..\vendors\realtek\sdk\amebaZ2\component\soc\realtek\8710c\fwlib\lib\include; ..\..\..\..\..\vendors\realtek\sdk\amebaZ2\component\soc\realtek\8710c\cmsis\cmsis-core\include; ..\..\..\..\..\vendors\realtek\sdk\amebaZ2\component\soc\realtek\8710c\cmsis\rtl8710c\include; ..\..\..\..\..\vendors\realtek\sdk\amebaZ2\component\soc\realtek\8710c\app\rtl_printf\include; ..\..\..\..\..\vendors\realtek\sdk\amebaZ2\component\soc\realtek\8710c\app\shell; ..\..\..\..\..\vendors\realtek\sdk\amebaZ2\component\soc\realtek\8710c\app\stdio_port; ..\..\..\..\..\vendors\realtek\sdk\amebaZ2\component\soc\realtek\8710c\misc\utilities\include; ..\..\..\..\..\vendors\realtek\sdk\amebaZ2\component\os\freertos; ..\..\..\..\..\vendors\realtek\sdk\amebaZ2\component\os\freertos\freertos_v10.0.1\Source\include; ..\..\..\..\..\vendors\realtek\sdk\amebaZ2\component\os\freertos\freertos_v10.0.1\Source\portable\IAR\ARM_RTL8710C; ..\..\..\..\..\vendors\realtek\sdk\amebaZ2\component\common\api; ..\..\..\..\..\vendors\realtek\sdk\amebaZ2\component\common\api\at_cmd; ..\..\..\..\..\vendors\realtek\sdk\amebaZ2\component\common\api\platform; ..\..\..\..\..\vendors\realtek\sdk\amebaZ2\component\common\api\wifi; ..\..\..\..\..\vendors\realtek\sdk\amebaZ2\component\common\api\network\include; ..\..\..\..\..\vendors\realtek\sdk\amebaZ2\component\common\application; ..\..\..\..\..\vendors\realtek\sdk\amebaZ2\component\common\application\mqtt\MQTTClient; ..\..\..\..\..\vendors\realtek\sdk\amebaZ2\component\common\example; ..\..\..\..\..\vendors\realtek\sdk\amebaZ2\component\common\file_system; ..\..\..\..\..\vendors\realtek\sdk\amebaZ2\component\common\file_system\dct; ..\..\..\..\..\vendors\realtek\sdk\amebaZ2\component\common\file_system\ftl; ..\..\..\..\..\vendors\realtek\sdk\amebaZ2\component\common\utilities; ..\..\..\..\..\vendors\realtek\sdk\amebaZ2\component\common\mbed\hal; ..\..\..\..\..\vendors\realtek\sdk\amebaZ2\component\common\mbed\hal_ext; ..\..\..\..\..\vendors\realtek\sdk\amebaZ2\component\common\mbed\targets\hal\rtl8710c; ..\..\..\..\..\vendors\realtek\sdk\amebaZ2\component\soc\realtek\8710c\mbed-drivers\include; ..\..\..\..\..\vendors\realtek\sdk\amebaZ2\component\os\os_dep\include; ..\..\..\..\..\vendors\realtek\sdk\amebaZ2\component\common\network; ..\..\..\..\..\vendors\realtek\sdk\amebaZ2\component\common\network\coap\include; ..\..\..\..\..\vendors\realtek\sdk\amebaZ2\component\common\network\http2\nghttp2-1.31.0\includes; ..\..\..\..\..\vendors\realtek\sdk\amebaZ2\component\common\network\lwip\lwip_v2.0.2\src\include; ..\..\..\..\..\vendors\realtek\sdk\amebaZ2\component\common\network\lwip\lwip_v2.0.2\src\include\lwip; ..\..\..\..\..\vendors\realtek\sdk\amebaZ2\component\common\network\lwip\lwip_v2.0.2\port\realtek; ..\..\..\..\..\vendors\realtek\sdk\amebaZ2\component\common\network\lwip\lwip_v2.0.2\port\realtek\freertos; ..\..\..\..\..\vendors\realtek\sdk\amebaZ2\component\common\api\wifi\rtw_wpa_supplicant\src; ..\..\..\..\..\vendors\realtek\sdk\amebaZ2\component\common\network\ssl\ssl_ram_map\rom; ..\..\..\..\..\vendors\realtek\sdk\amebaZ2\component\common\drivers\wlan\realtek\include; ..\..\..\..\..\vendors\realtek\sdk\amebaZ2\component\common\drivers\wlan\realtek\src\osdep; ..\..\..\..\..\vendors\realtek\sdk\amebaZ2\component\common\mbed\targets\hal\rtl8710c; ..\..\..\..\..\vendors\realtek\sdk\amebaZ2\component\common\test; ..\..\..\..\..\vendors\realtek\sdk\amebaZ2\component\common\bluetooth\realtek\sdk; ..\..\..\..\..\vendors\realtek\sdk\amebaZ2\component\common\bluetooth\realtek\sdk\inc; ..\..\..\..\..\vendors\realtek\sdk\amebaZ2\component\common\bluetooth\realtek\sdk\inc\app; ..\..\..\..\..\vendors\realtek\sdk\amebaZ2\component\common\bluetooth\realtek\sdk\inc\bluetooth\gap; ..\..\..\..\..\vendors\realtek\sdk\amebaZ2\component\common\bluetooth\realtek\sdk\inc\bluetooth\profile; ..\..\..\..\..\vendors\realtek\sdk\amebaZ2\component\common\bluetooth\realtek\sdk\inc\bluetooth\profile\client; ..\..\..\..\..\vendors\realtek\sdk\amebaZ2\component\common\bluetooth\realtek\sdk\inc\bluetooth\profile\server; ..\..\..\..\..\vendors\realtek\sdk\amebaZ2\component\common\bluetooth\realtek\sdk\inc\os; ..\..\..\..\..\vendors\realtek\sdk\amebaZ2\component\common\bluetooth\realtek\sdk\inc\platform; ..\..\..\..\..\vendors\realtek\sdk\amebaZ2\component\common\bluetooth\realtek\sdk\inc\stack; ..\..\..\..\..\vendors\realtek\sdk\amebaZ2\component\common\bluetooth\realtek\sdk\board\amebaz2\lib; ..\..\..\..\..\vendors\realtek\sdk\amebaZ2\component\common\bluetooth\realtek\sdk\board\amebaz2\src; ..\..\..\..\..\vendors\realtek\sdk\amebaZ2\component\common\bluetooth\realtek\sdk\board\amebaz2\src\data_uart; ..\..\..\..\..\vendors\realtek\sdk\amebaZ2\component\common\bluetooth\realtek\sdk\board\amebaz2\src\hci; ..\..\..\..\..\vendors\realtek\sdk\amebaZ2\component\common\bluetooth\realtek\sdk\board\amebaz2\src\os; ..\..\..\..\..\vendors\realtek\sdk\amebaZ2\component\common\bluetooth\realtek\sdk\board\amebaz2\src\vendor_cmd; ..\..\..\..\..\vendors\realtek\sdk\amebaZ2\component\common\bluetooth\realtek\sdk\example\bt_config; ..\..\..\..\..\vendors\realtek\sdk\amebaZ2\component\common\bluetooth\realtek\sdk\example\ble_central; ..\..\..\..\..\vendors\realtek\sdk\amebaZ2\component\common\bluetooth\realtek\sdk\example\ble_peripheral; ..\..\..\..\..\vendors\realtek\sdk\amebaZ2\component\common\bluetooth\realtek\sdk\example\ble_scatternet; ..\..\..\..\..\vendors\realtek\sdk\amebaZ2\component\common\bluetooth\realtek\sdk\src\mcu\module\data_uart_cmd; ..\..\..\..\..\vendors\realtek\sdk\amebaZ2\component\soc\realtek\8710c\misc\platform; ..\..\..\..\..\vendors\realtek\sdk\amebaZ2\component\common\bluetooth\realtek\sdk\board\common\inc; ..\..\..\..\..\vendors\realtek\sdk\amebaZ2\component\soc\realtek\8710c\misc\driver; ..\..\..\..\..\vendors\realtek\sdk\amebaZ2\component\soc\realtek\8710c\misc\os; ..\..\..\..\..\vendors\realtek\sdk\amebaZ2\component\common\drivers\wlan\realtek\src\core\option; ..\..\..\..\..\vendors\realtek\sdk\amebaZ2\component\common\api\wifi\rtw_wpa_supplicant\src\crypto; ..\..\..\..\..\vendors\realtek\sdk\amebaZ2\component\common\file_system\fatfs; ..\..\..\..\..\vendors\realtek\sdk\amebaZ2\component\common\file_system\fatfs\r0.10c\include; ..\..\..\..\..\vendors\realtek\sdk\amebaZ2\component\common\network\libcoap\include; ..\..\..\..\..\vendors\realtek\sdk\amebaZ2\component\common\bluetooth\realtek\sdk\example\bt_mesh\lib\cmd; ..\..\..\..\..\vendors\realtek\sdk\amebaZ2\component\common\bluetooth\realtek\sdk\example\bt_mesh\lib\common; ..\..\..\..\..\vendors\realtek\sdk\amebaZ2\component\common\bluetooth\realtek\sdk\example\bt_mesh\lib\gap; ..\..\..\..\..\vendors\realtek\sdk\amebaZ2\component\common\bluetooth\realtek\sdk\example\bt_mesh\lib\inc; ..\..\..\..\..\vendors\realtek\sdk\amebaZ2\component\common\bluetooth\realtek\sdk\example\bt_mesh\lib\inc\amebaz2; ..\..\..\..\..\vendors\realtek\sdk\amebaZ2\component\common\bluetooth\realtek\sdk\example\bt_mesh\lib\model; ..\..\..\..\..\vendors\realtek\sdk\amebaZ2\component\common\bluetooth\realtek\sdk\example\bt_mesh\lib\model\realtek; ..\..\..\..\..\vendors\realtek\sdk\amebaZ2\component\common\bluetooth\realtek\sdk\example\bt_mesh\lib\platform; ..\..\..\..\..\vendors\realtek\sdk\amebaZ2\component\common\bluetooth\realtek\sdk\example\bt_mesh\lib\profile; ..\..\..\..\..\vendors\realtek\sdk\amebaZ2\component\common\bluetooth\realtek\sdk\example\bt_mesh\provisioner; ..\..\..\..\..\vendors\realtek\sdk\amebaZ2\component\common\bluetooth\realtek\sdk\example\bt_mesh\device; ..\..\..\..\..\vendors\realtek\sdk\amebaZ2\component\common\bluetooth\realtek\sdk\example\bt_mesh_device_rtk_demo; ..\..\..\..\..\vendors\realtek\sdk\amebaZ2\component\common\bluetooth\realtek\sdk\example\bt_mesh_provisioner_rtk_demo; ..\..\..\..\..\vendors\realtek\sdk\amebaZ2\component\common\bluetooth\realtek\sdk\example\bt_mesh_provisioner_rtk_demo\inc; ..\..\..\..\..\vendors\realtek\sdk\amebaZ2\component\common\bluetooth\realtek\sdk\example\bt_mesh\api; ..\..\..\..\..\vendors\realtek\sdk\amebaZ2\component\common\bluetooth\realtek\sdk\example\bt_mesh\api\device; ..\..\..\..\..\vendors\realtek\sdk\amebaZ2\component\common\bluetooth\realtek\sdk\example\bt_mesh\api\provisioner; ..\..\..\..\..\vendors\realtek\sdk\amebaZ2\component\common\media\rtp_codec; ..\..\..\..\..\vendors\realtek\sdk\amebaZ2\component\common\bluetooth\realtek\sdk\example\bt_airsync_config; ..\..\..\..\..\vendors\realtek\sdk\amebaZ2\component\common\application\airsync\1.0.4; ..\..\..\..\..\vendors\realtek\sdk\amebaZ2\component\common\example\amazon_afqp_tests; ..\..\..\..\..\vendors\realtek\boards\amebaZ2\aws_tests\config_files; ..\..\..\..\..\demos\dev_mode_key_provisioning\include; ..\..\..\..\..\libraries\abstractions\pkcs11\include; ..\..\..\..\..\libraries\abstractions\pkcs11\mbedtls; ..\..\..\..\..\libraries\abstractions\platform\include; ..\..\..\..\..\libraries\abstractions\platform\freertos\include; ..\..\..\..\..\libraries\abstractions\platform\freertos\include\platform; ..\..\..\..\..\libraries\abstractions\secure_sockets\include; ..\..\..\..\..\libraries\abstractions\wifi\include; ..\..\..\..\..\libraries\abstractions\wifi\test; ..\..\..\..\..\libraries\c_sdk\standard\common\include; ..\..\..\..\..\libraries\c_sdk\standard\common\include\private; ..\..\..\..\..\libraries\c_sdk\standard\mqtt\include; ..\..\..\..\..\libraries\c_sdk\standard\mqtt\src; ..\..\..\..\..\libraries\c_sdk\standard\mqtt\src\private; ..\..\..\..\..\libraries\c_sdk\standard\mqtt\test\access; ..\..\..\..\..\libraries\c_sdk\standard\mqtt\test\mock; ..\..\..\..\..\libraries\freertos_plus\aws\ota\include; ..\..\..\..\..\libraries\freertos_plus\aws\ota\src; ..\..\..\..\..\libraries\freertos_plus\aws\ota\src\mqtt; ..\..\..\..\..\libraries\freertos_plus\aws\ota\test; ..\..\..\..\..\libraries\freertos_plus\standard\crypto\include; ..\..\..\..\..\libraries\freertos_plus\standard\pkcs11\include; ..\..\..\..\..\libraries\freertos_plus\standard\tls\include; ..\..\..\..\..\libraries\freertos_plus\standard\tls\test; ..\..\..\..\..\libraries\freertos_plus\standard\utils\include; ..\..\..\..\..\libraries\3rdparty\jsmn; ..\..\..\..\..\libraries\3rdparty\mbedtls\include; ..\..\..\..\..\libraries\3rdparty\mbedtls_config; ..\..\..\..\..\libraries\3rdparty\mbedtls_utils; ..\..\..\..\..\libraries\3rdparty\tinycbor; ..\..\..\..\..\libraries\3rdparty\tinycbor\src; ..\..\..\..\..\libraries\3rdparty\unity\src; ..\..\..\..\..\libraries\3rdparty\unity\extras\fixture\src; ..\..\..\..\..\libraries\3rdparty\pkcs11; ..\..\..\..\..\tests\include; ..\..\..\..\..\freertos_kernel\include; ..\..\..\..\..\tools\cbmc\windows
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 2
  AARM.ADefines: V8M_STKOVF
  AARM.AUserIncludes: ..\..\..\..\..\vendors\realtek\sdk\amebaZ2\project\realtek_amebaz2_v0_example\inc; ..\..\..\..\..\vendors\realtek\sdk\amebaZ2\component\soc\realtek\8710c\cmsis; ..\..\..\..\..\vendors\realtek\sdk\amebaZ2\component\os\os_dep\include; ..\..\..\..\..\vendors\realtek\sdk\amebaZ2\component\os\freertos\freertos_v10.0.1\Source\include; ..\..\..\..\..\vendors\realtek\sdk\amebaZ2\component\os\freertos\freertos_v10.0.1\Source\portable\IAR\ARM_RTL8710C
  OBJCOPY.OOCOutputFile: application_is.srec
  prebuild: CSCRIPT  "..\..\..\..\..\vendors\realtek\sdk\amebaZ2\component\soc\realtek\8710c\misc\iar_utility\prebuild.vbs" "$PROJ_DIR$"
  postbuild: CSCRIPT  "..\..\..\..\..\vendors\realtek\sdk\amebaZ2\component\soc\realtek\8710c\misc\iar_utility\postbuild_is.vbs" "$TARGET_DIR$" "$PROJ_DIR$" "Debug" "$TOOLKIT_DIR$"
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkKeepSymbols: ram_start
  ILINK.IlinkIcfFile: application_is.icf
  ILINK.IlinkExtraOptions: --redirect malloc=__wrap_malloc; --redirect realloc=__wrap_realloc; --redirect free=__wrap_free; --redirect printf=__wrap_printf; --redirect sprintf=__wrap_sprintf; --redirect snprintf=__wrap_snprintf; --redirect vsnprintf=__wrap_vsnprintf; --redirect memcmp=__wrap_memcmp; --redirect memcpy=__wrap_memcpy; --redirect memmove=__wrap_memmove; --redirect memset=__wrap_memset; --redirect strcat=__wrap_strcat; --redirect strchr=__wrap_strchr; --redirect strcmp=__wrap_strcmp; --redirect strncmp=__wrap_strncmp; --redirect strnicmp=__wrap_strnicmp; --redirect strcpy=__wrap_strcpy; --redirect strncpy=__wrap_strncpy; --redirect strlcpy=__wrap_strlcpy; --redirect strlen=__wrap_strlen; --redirect strnlen=__wrap_strnlen; --redirect strncat=__wrap_strncat; --redirect strpbrk=__wrap_strpbrk; --redirect strspn=__wrap_strspn; --redirect strstr=__wrap_strstr; --redirect strtok=__wrap_strtok; --redirect strxfrm=__wrap_strxfrm; --redirect strsep=__wrap_strsep; --redirect strtod=__wrap_strtod; --redirect strtof=__wrap_strtof; --redirect strtold=__wrap_strtold; --redirect strtoll=__wrap_strtoll; --redirect strtoul=__wrap_strtoul; --redirect strtoull=__wrap_strtoull; --redirect atoi=__wrap_atoi; --redirect atoui=__wrap_atoui; --redirect atol=__wrap_atol; --redirect atoul=__wrap_atoul; --redirect atoull=__wrap_atoull; --redirect atof=__wrap_atof; --skip_dynamic_initialization; --redirect aesccmp_construct_mic_iv=aesccmp_construct_mic_iv_ram; --redirect aesccmp_construct_mic_header1=aesccmp_construct_mic_header1_ram; --redirect aesccmp_construct_ctr_preload=aesccmp_construct_ctr_preload_ram; --redirect rom_psk_CalcGTK=ram_patch_rom_psk_CalcGTK; --redirect rom_psk_CalcPTK=ram_patch_rom_psk_CalcPTK; --redirect aes_80211_encrypt=ram_patch_aes_80211_encrypt; --redirect aes_80211_decrypt=ram_patch_aes_80211_decrypt
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration Debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: __thumb2__; CONFIG_PLATFORM_8710C; __ARM_ARCH_8M_MAIN__=1; CONFIG_BUILD_RAM=1; _NO_DEFINITIONS_IN_HEADER_FILES; V8M_STKOVF
  ICCARM.CCIncludePath2: ..\..\..\..\..\vendors\realtek\sdk\amebaZ2\project\realtek_amebaz2_v0_example\inc; ..\..\..\..\..\vendors\realtek\sdk\amebaZ2\component\soc\realtek\8710c\cmsis\rtl8710c\include; ..\..\..\..\..\vendors\realtek\sdk\amebaZ2\component\soc\realtek\8710c\cmsis\rtl8710c\lib\include; ..\..\..\..\..\vendors\realtek\sdk\amebaZ2\component\soc\realtek\8710c\fwlib\include; ..\..\..\..\..\vendors\realtek\sdk\amebaZ2\component\soc\realtek\8710c\fwlib\lib\include; ..\..\..\..\..\vendors\realtek\sdk\amebaZ2\component\soc\realtek\8710c\cmsis\cmsis-core\include; ..\..\..\..\..\vendors\realtek\sdk\amebaZ2\component\soc\realtek\8710c\cmsis\rtl8710c\include; ..\..\..\..\..\vendors\realtek\sdk\amebaZ2\component\soc\realtek\8710c\app\rtl_printf\include; ..\..\..\..\..\vendors\realtek\sdk\amebaZ2\component\soc\realtek\8710c\app\shell; ..\..\..\..\..\vendors\realtek\sdk\amebaZ2\component\soc\realtek\8710c\app\stdio_port; ..\..\..\..\..\vendors\realtek\sdk\amebaZ2\component\soc\realtek\8710c\misc\utilities\include; ..\..\..\..\..\vendors\realtek\sdk\amebaZ2\component\os\freertos; ..\..\..\..\..\vendors\realtek\sdk\amebaZ2\component\os\freertos\freertos_v10.0.1\Source\include; ..\..\..\..\..\vendors\realtek\sdk\amebaZ2\component\os\freertos\freertos_v10.0.1\Source\portable\IAR\ARM_RTL8710C; ..\..\..\..\..\vendors\realtek\sdk\amebaZ2\component\common\api; ..\..\..\..\..\vendors\realtek\sdk\amebaZ2\component\common\api\at_cmd; ..\..\..\..\..\vendors\realtek\sdk\amebaZ2\component\common\api\platform; ..\..\..\..\..\vendors\realtek\sdk\amebaZ2\component\common\api\wifi; ..\..\..\..\..\vendors\realtek\sdk\amebaZ2\component\common\api\network\include; ..\..\..\..\..\vendors\realtek\sdk\amebaZ2\component\common\application; ..\..\..\..\..\vendors\realtek\sdk\amebaZ2\component\common\application\mqtt\MQTTClient; ..\..\..\..\..\vendors\realtek\sdk\amebaZ2\component\common\example; ..\..\..\..\..\vendors\realtek\sdk\amebaZ2\component\common\file_system; ..\..\..\..\..\vendors\realtek\sdk\amebaZ2\component\common\file_system\dct; ..\..\..\..\..\vendors\realtek\sdk\amebaZ2\component\common\file_system\ftl; ..\..\..\..\..\vendors\realtek\sdk\amebaZ2\component\common\utilities; ..\..\..\..\..\vendors\realtek\sdk\amebaZ2\component\common\mbed\hal; ..\..\..\..\..\vendors\realtek\sdk\amebaZ2\component\common\mbed\hal_ext; ..\..\..\..\..\vendors\realtek\sdk\amebaZ2\component\common\mbed\targets\hal\rtl8710c; ..\..\..\..\..\vendors\realtek\sdk\amebaZ2\component\soc\realtek\8710c\mbed-drivers\include; ..\..\..\..\..\vendors\realtek\sdk\amebaZ2\component\os\os_dep\include; ..\..\..\..\..\vendors\realtek\sdk\amebaZ2\component\common\network; ..\..\..\..\..\vendors\realtek\sdk\amebaZ2\component\common\network\coap\include; ..\..\..\..\..\vendors\realtek\sdk\amebaZ2\component\common\network\http2\nghttp2-1.31.0\includes; ..\..\..\..\..\vendors\realtek\sdk\amebaZ2\component\common\network\lwip\lwip_v2.0.2\src\include; ..\..\..\..\..\vendors\realtek\sdk\amebaZ2\component\common\network\lwip\lwip_v2.0.2\src\include\lwip; ..\..\..\..\..\vendors\realtek\sdk\amebaZ2\component\common\network\lwip\lwip_v2.0.2\port\realtek; ..\..\..\..\..\vendors\realtek\sdk\amebaZ2\component\common\network\lwip\lwip_v2.0.2\port\realtek\freertos; ..\..\..\..\..\vendors\realtek\sdk\amebaZ2\component\common\api\wifi\rtw_wpa_supplicant\src; ..\..\..\..\..\vendors\realtek\sdk\amebaZ2\component\common\network\ssl\mbedtls-2.4.0\include; ..\..\..\..\..\vendors\realtek\sdk\amebaZ2\component\common\network\ssl\ssl_ram_map\rom; ..\..\..\..\..\vendors\realtek\sdk\amebaZ2\component\common\drivers\wlan\realtek\include; ..\..\..\..\..\vendors\realtek\sdk\amebaZ2\component\common\drivers\wlan\realtek\src\osdep; ..\..\..\..\..\vendors\realtek\sdk\amebaZ2\component\common\mbed\targets\hal\rtl8710c; ..\..\..\..\..\vendors\realtek\sdk\amebaZ2\component\common\test; ..\..\..\..\..\vendors\realtek\sdk\amebaZ2\component\common\bluetooth\realtek\sdk; ..\..\..\..\..\vendors\realtek\sdk\amebaZ2\component\common\bluetooth\realtek\sdk\inc; ..\..\..\..\..\vendors\realtek\sdk\amebaZ2\component\common\bluetooth\realtek\sdk\inc\app; ..\..\..\..\..\vendors\realtek\sdk\amebaZ2\component\common\bluetooth\realtek\sdk\inc\bluetooth\gap; ..\..\..\..\..\vendors\realtek\sdk\amebaZ2\component\common\bluetooth\realtek\sdk\inc\bluetooth\profile; ..\..\..\..\..\vendors\realtek\sdk\amebaZ2\component\common\bluetooth\realtek\sdk\inc\bluetooth\profile\client; ..\..\..\..\..\vendors\realtek\sdk\amebaZ2\component\common\bluetooth\realtek\sdk\inc\bluetooth\profile\server; ..\..\..\..\..\vendors\realtek\sdk\amebaZ2\component\common\bluetooth\realtek\sdk\inc\os; ..\..\..\..\..\vendors\realtek\sdk\amebaZ2\component\common\bluetooth\realtek\sdk\inc\platform; ..\..\..\..\..\vendors\realtek\sdk\amebaZ2\component\common\bluetooth\realtek\sdk\inc\stack; ..\..\..\..\..\vendors\realtek\sdk\amebaZ2\component\common\bluetooth\realtek\sdk\board\amebaz2\lib; ..\..\..\..\..\vendors\realtek\sdk\amebaZ2\component\common\bluetooth\realtek\sdk\board\amebaz2\src; ..\..\..\..\..\vendors\realtek\sdk\amebaZ2\component\common\bluetooth\realtek\sdk\board\amebaz2\src\data_uart; ..\..\..\..\..\vendors\realtek\sdk\amebaZ2\component\common\bluetooth\realtek\sdk\board\amebaz2\src\hci; ..\..\..\..\..\vendors\realtek\sdk\amebaZ2\component\common\bluetooth\realtek\sdk\board\amebaz2\src\os; ..\..\..\..\..\vendors\realtek\sdk\amebaZ2\component\common\bluetooth\realtek\sdk\board\amebaz2\src\vendor_cmd; ..\..\..\..\..\vendors\realtek\sdk\amebaZ2\component\common\bluetooth\realtek\sdk\example\bt_config; ..\..\..\..\..\vendors\realtek\sdk\amebaZ2\component\common\bluetooth\realtek\sdk\example\ble_central; ..\..\..\..\..\vendors\realtek\sdk\amebaZ2\component\common\bluetooth\realtek\sdk\example\ble_peripheral; ..\..\..\..\..\vendors\realtek\sdk\amebaZ2\component\common\bluetooth\realtek\sdk\example\ble_scatternet; ..\..\..\..\..\vendors\realtek\sdk\amebaZ2\component\common\bluetooth\realtek\sdk\src\mcu\module\data_uart_cmd; ..\..\..\..\..\vendors\realtek\sdk\amebaZ2\component\soc\realtek\8710c\misc\platform; ..\..\..\..\..\vendors\realtek\sdk\amebaZ2\component\common\bluetooth\realtek\sdk\board\common\inc; ..\..\..\..\..\vendors\realtek\sdk\amebaZ2\component\soc\realtek\8710c\misc\driver; ..\..\..\..\..\vendors\realtek\sdk\amebaZ2\component\soc\realtek\8710c\misc\os; ..\..\..\..\..\vendors\realtek\sdk\amebaZ2\component\common\drivers\wlan\realtek\src\core\option; ..\..\..\..\..\vendors\realtek\sdk\amebaZ2\component\common\api\wifi\rtw_wpa_supplicant\src\crypto; ..\..\..\..\..\vendors\realtek\sdk\amebaZ2\component\common\file_system\fatfs; ..\..\..\..\..\vendors\realtek\sdk\amebaZ2\component\common\file_system\fatfs\r0.10c\include; ..\..\..\..\..\vendors\realtek\sdk\amebaZ2\component\common\network\libcoap\include; ..\..\..\..\..\vendors\realtek\sdk\amebaZ2\component\common\bluetooth\realtek\sdk\example\bt_mesh\lib\cmd; ..\..\..\..\..\vendors\realtek\sdk\amebaZ2\component\common\bluetooth\realtek\sdk\example\bt_mesh\lib\common; ..\..\..\..\..\vendors\realtek\sdk\amebaZ2\component\common\bluetooth\realtek\sdk\example\bt_mesh\lib\gap; ..\..\..\..\..\vendors\realtek\sdk\amebaZ2\component\common\bluetooth\realtek\sdk\example\bt_mesh\lib\inc; ..\..\..\..\..\vendors\realtek\sdk\amebaZ2\component\common\bluetooth\realtek\sdk\example\bt_mesh\lib\inc\amebaz2; ..\..\..\..\..\vendors\realtek\sdk\amebaZ2\component\common\bluetooth\realtek\sdk\example\bt_mesh\lib\model; ..\..\..\..\..\vendors\realtek\sdk\amebaZ2\component\common\bluetooth\realtek\sdk\example\bt_mesh\lib\model\realtek; ..\..\..\..\..\vendors\realtek\sdk\amebaZ2\component\common\bluetooth\realtek\sdk\example\bt_mesh\lib\platform; ..\..\..\..\..\vendors\realtek\sdk\amebaZ2\component\common\bluetooth\realtek\sdk\example\bt_mesh\lib\profile; ..\..\..\..\..\vendors\realtek\sdk\amebaZ2\component\common\bluetooth\realtek\sdk\example\bt_mesh\provisioner; ..\..\..\..\..\vendors\realtek\sdk\amebaZ2\component\common\bluetooth\realtek\sdk\example\bt_mesh\device; ..\..\..\..\..\vendors\realtek\sdk\amebaZ2\component\common\bluetooth\realtek\sdk\example\bt_mesh_device_rtk_demo; ..\..\..\..\..\vendors\realtek\sdk\amebaZ2\component\common\bluetooth\realtek\sdk\example\bt_mesh_provisioner_rtk_demo; ..\..\..\..\..\vendors\realtek\sdk\amebaZ2\component\common\bluetooth\realtek\sdk\example\bt_mesh_provisioner_rtk_demo\inc; ..\..\..\..\..\vendors\realtek\sdk\amebaZ2\component\common\bluetooth\realtek\sdk\example\bt_mesh\api; ..\..\..\..\..\vendors\realtek\sdk\amebaZ2\component\common\bluetooth\realtek\sdk\example\bt_mesh\api\device; ..\..\..\..\..\vendors\realtek\sdk\amebaZ2\component\common\bluetooth\realtek\sdk\example\bt_mesh\api\provisioner; ..\..\..\..\..\vendors\realtek\sdk\amebaZ2\component\common\media\rtp_codec; ..\..\..\..\..\vendors\realtek\sdk\amebaZ2\component\common\bluetooth\realtek\sdk\example\bt_airsync_config; ..\..\..\..\..\vendors\realtek\sdk\amebaZ2\component\common\application\airsync\1.0.4; ..\..\..\..\..\vendors\realtek\sdk\amebaZ2\component\common\bluetooth\realtek\sdk\example\bt_mesh_multiple_profile\device_multiple_profile; ..\..\..\..\..\vendors\realtek\sdk\amebaZ2\component\common\bluetooth\realtek\sdk\example\bt_mesh_multiple_profile\provisioner_multiple_profile
  postbuild: CSCRIPT  "..\..\..\..\..\vendors\realtek\sdk\amebaZ2\component\soc\realtek\8710c\misc\iar_utility\postbuild_is.vbs" "$TARGET_DIR$" "$PROJ_DIR$" "$CONFIG_NAME$" "$TOOLKIT_DIR$"
  ILINK.IlinkExtraOptions: --redirect malloc=__wrap_malloc; --redirect realloc=__wrap_realloc; --redirect free=__wrap_free; --redirect printf=__wrap_printf; --redirect sprintf=__wrap_sprintf; --redirect snprintf=__wrap_snprintf; --redirect vsnprintf=__wrap_vsnprintf; --redirect memcmp=__wrap_memcmp; --redirect memcpy=__wrap_memcpy; --redirect memmove=__wrap_memmove; --redirect memset=__wrap_memset; --redirect strcat=__wrap_strcat; --redirect strchr=__wrap_strchr; --redirect strcmp=__wrap_strcmp; --redirect strncmp=__wrap_strncmp; --redirect strnicmp=__wrap_strnicmp; --redirect strcpy=__wrap_strcpy; --redirect strncpy=__wrap_strncpy; --redirect strlcpy=__wrap_strlcpy; --redirect strlen=__wrap_strlen; --redirect strnlen=__wrap_strnlen; --redirect strncat=__wrap_strncat; --redirect strpbrk=__wrap_strpbrk; --redirect strspn=__wrap_strspn; --redirect strstr=__wrap_strstr; --redirect strtok=__wrap_strtok; --redirect strxfrm=__wrap_strxfrm; --redirect strsep=__wrap_strsep; --redirect strtod=__wrap_strtod; --redirect strtof=__wrap_strtof; --redirect strtold=__wrap_strtold; --redirect strtoll=__wrap_strtoll; --redirect strtoul=__wrap_strtoul; --redirect strtoull=__wrap_strtoull; --redirect atoi=__wrap_atoi; --redirect atoui=__wrap_atoui; --redirect atol=__wrap_atol; --redirect atoul=__wrap_atoul; --redirect atoull=__wrap_atoull; --redirect atof=__wrap_atof; --redirect __localtime64=__wrap_localtime; --redirect __mktime64=__wrap_mktime; --skip_dynamic_initialization; --redirect aesccmp_construct_mic_iv=aesccmp_construct_mic_iv_ram; --redirect aesccmp_construct_mic_header1=aesccmp_construct_mic_header1_ram; --redirect aesccmp_construct_ctr_preload=aesccmp_construct_ctr_preload_ram; --redirect rom_psk_CalcGTK=ram_patch_rom_psk_CalcGTK; --redirect rom_psk_CalcPTK=ram_patch_rom_psk_CalcPTK; --redirect aes_80211_encrypt=ram_patch_aes_80211_encrypt; --redirect aes_80211_decrypt=ram_patch_aes_80211_decrypt
  group @SRAM
    ../../../../../vendors/realtek/sdk/amebaZ2/component/common/mbed/targets/hal/rtl8710c/: flash_api.c power_mode_api.c
    ../../../../../vendors/realtek/sdk/amebaZ2/component/soc/realtek/8710c/misc/driver/: flash_api_ext.c
    ../../../../../vendors/realtek/sdk/amebaZ2/component/common/file_system/fatfs/disk_if/src/: flash_fatfs.c
    ../../../../../vendors/realtek/sdk/amebaZ2/component/soc/realtek/8710c/fwlib/source/ram_ns/: hal_flash.c hal_spic.c
  group amazon/demos
    ../../../../../demos/dev_mode_key_provisioning/src/: aws_dev_mode_key_provisioning.c
  group amazon/libraries/3rdparty/jsmn
    ../../../../../libraries/3rdparty/jsmn/: jsmn.c
  group amazon/libraries/3rdparty/mbedtls/library
    ../../../../../libraries/3rdparty/mbedtls/library/: aes.c aesni.c arc4.c aria.c asn1parse.c asn1write.c base64.c bignum.c blowfish.c camellia.c ccm.c certs.c chacha20.c chachapoly.c cipher.c cipher_wrap.c cmac.c ctr_drbg.c debug.c des.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c entropy.c entropy_poll.c error.c gcm.c havege.c hkdf.c hmac_drbg.c md.c md2.c md4.c md5.c md_wrap.c memory_buffer_alloc.c net_sockets.c nist_kw.c oid.c padlock.c pem.c pk.c pk_wrap.c pkcs11.c pkcs12.c pkcs5.c pkparse.c pkwrite.c platform.c platform_util.c poly1305.c ripemd160.c rsa.c rsa_internal.c sha1.c sha256.c sha512.c ssl_cache.c ssl_ciphersuites.c ssl_cli.c ssl_cookie.c ssl_srv.c ssl_ticket.c ssl_tls.c threading.c timing.c version.c version_features.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509write_crt.c x509write_csr.c xtea.c
  group amazon/libraries/3rdparty/mbedtls_utils
    ../../../../../libraries/3rdparty/mbedtls_utils/: mbedtls_error.c mbedtls_utils.c
  group amazon/libraries/3rdparty/tinycbor
    ../../../../../libraries/3rdparty/tinycbor/src/: cborencoder.c cborencoder_close_container_checked.c cborerrorstrings.c cborparser.c cborparser_dup_string.c cborpretty.c cborvalidation.c
  group amazon/libraries/3rdparty/unity
    ../../../../../libraries/3rdparty/unity/src/: unity.c
    ../../../../../libraries/3rdparty/unity/extras/fixture/src/: unity_fixture.c
  group amazon/libraries/abstractions/pkcs11
    ../../../../../libraries/abstractions/pkcs11/mbedtls/: iot_pkcs11_mbedtls.c
  group amazon/libraries/abstractions/platform/freertos
    ../../../../../libraries/abstractions/platform/freertos/: iot_clock_freertos.c iot_metrics.c iot_network_freertos.c iot_threads_freertos.c
  group amazon/libraries/abstractions/test
    ../../../../../libraries/abstractions/pkcs11/test/: iot_test_pkcs11.c
    ../../../../../libraries/abstractions/secure_sockets/test/: iot_test_tcp.c
    ../../../../../libraries/abstractions/wifi/test/: iot_test_wifi.c
  group amazon/libraries/c_sdk/standard/common
    ../../../../../vendors/realtek/boards/amebaZ2/libraries/c_sdk/standard/common/: iot_device_metrics.c
    ../../../../../libraries/c_sdk/standard/common/: iot_init.c iot_static_memory_common.c
  group amazon/libraries/c_sdk/standard/common/logging
    ../../../../../libraries/c_sdk/standard/common/logging/: iot_logging.c iot_logging_task_dynamic_buffers.c
  group amazon/libraries/c_sdk/standard/common/taskpool
    ../../../../../libraries/c_sdk/standard/common/taskpool/: iot_taskpool.c iot_taskpool_static_memory.c
  group amazon/libraries/c_sdk/standard/mqtt
    ../../../../../libraries/c_sdk/standard/mqtt/src/: iot_mqtt_agent.c iot_mqtt_api.c iot_mqtt_network.c iot_mqtt_operation.c iot_mqtt_serialize.c iot_mqtt_static_memory.c iot_mqtt_subscription.c iot_mqtt_validate.c
  group amazon/libraries/c_sdk/standard/test
    ../../../../../libraries/c_sdk/standard/mqtt/test/access/: iot_test_access_mqtt_api.c iot_test_access_mqtt_subscription.c
    ../../../../../libraries/c_sdk/standard/mqtt/test/: iot_test_mqtt_agent.c
    ../../../../../libraries/c_sdk/standard/mqtt/test/unit/: iot_tests_mqtt_api.c iot_tests_mqtt_metrics.c iot_tests_mqtt_receive.c iot_tests_mqtt_subscription.c iot_tests_mqtt_validate.c
    ../../../../../libraries/c_sdk/standard/mqtt/test/mock/: iot_tests_mqtt_mock.c
    ../../../../../libraries/c_sdk/standard/mqtt/test/system/: iot_tests_mqtt_system.c
  group amazon/libraries/freertos_plus/aws
    ../../../../../libraries/freertos_plus/aws/ota/src/: aws_iot_ota_agent.c aws_iot_ota_interface.c
    ../../../../../libraries/freertos_plus/aws/ota/src/mqtt/: aws_iot_ota_cbor.c
    ../../../../../vendors/realtek/boards/amebaZ2/libraries/freertos_plus/aws/ota/src/mqtt/: aws_iot_ota_mqtt.c
  group amazon/libraries/freertos_plus/standard/crypto
    ../../../../../libraries/freertos_plus/standard/crypto/src/: iot_crypto.c
  group amazon/libraries/freertos_plus/standard/pkcs11
    ../../../../../libraries/freertos_plus/standard/pkcs11/src/: iot_pkcs11.c
  group amazon/libraries/freertos_plus/standard/tls
    ../../../../../libraries/freertos_plus/standard/tls/src/: iot_tls.c
  group amazon/libraries/freertos_plus/standard/utils
    ../../../../../libraries/freertos_plus/standard/utils/src/: iot_pki_utils.c iot_system_init.c
  group amazon/libraries/freertos_plus/test
    ../../../../../libraries/freertos_plus/aws/ota/test/: aws_test_ota_agent.c aws_test_ota_pal.c
    ../../../../../libraries/freertos_plus/standard/tls/test/: iot_test_tls.c
  group amazon/tests/common
    ../../../../../tests/common/: aws_test.c aws_test_framework.c aws_test_runner.c iot_test_freertos.c iot_tests_network.c
  group amazon/vendors
    ../../../../../vendors/realtek/boards/amebaZ2/aws_tests/application_code/: aws_test_main.c
  group amazon/vendors/port
    ../../../../../vendors/realtek/boards/amebaZ2/ports/ota/: aws_ota_amebaZ2.c aws_ota_pal.c
    ../../../../../vendors/realtek/boards/amebaZ2/ports/pkcs11/: iot_pkcs11_pal.c
    ../../../../../vendors/realtek/boards/amebaZ2/ports/secure_sockets/: iot_secure_sockets.c
    ../../../../../vendors/realtek/boards/amebaZ2/ports/wifi/: iot_wifi.c
  group bluetooth/board
    ../../../../../vendors/realtek/sdk/amebaZ2/component/common/bluetooth/realtek/sdk/board/amebaz2/src/hci/: bt_fwconfig.c bt_mp_patch.c bt_normal_patch.c hci_board.c hci_uart.c
    ../../../../../vendors/realtek/sdk/amebaZ2/component/common/bluetooth/realtek/sdk/board/common/src/: cycle_queue.c
    ../../../../../vendors/realtek/sdk/amebaZ2/component/common/bluetooth/realtek/sdk/board/amebaz2/src/data_uart/: data_uart.c
    ../../../../../vendors/realtek/sdk/amebaZ2/component/common/bluetooth/realtek/sdk/board/common/os/freertos/: osif_freertos.c
    ../../../../../vendors/realtek/sdk/amebaZ2/component/common/bluetooth/realtek/sdk/board/amebaz2/src/: platform_utils.c rtk_coex.c trace_uart.c
    ../../../../../vendors/realtek/sdk/amebaZ2/component/common/bluetooth/realtek/sdk/board/amebaz2/src/vendor_cmd/: vendor_cmd.c
  group bluetooth/common
    ../../../../../vendors/realtek/sdk/amebaZ2/component/common/bluetooth/realtek/sdk/src/ble/profile/client/: ancs_client.c bas_client.c gaps_client.c simple_ble_client.c
    ../../../../../vendors/realtek/sdk/amebaZ2/component/common/bluetooth/realtek/sdk/src/ble/profile/server/: bas.c dis.c hids.c hids_kb.c hids_rmc.c simple_ble_service.c
    ../../../../../vendors/realtek/sdk/amebaZ2/component/common/bluetooth/realtek/sdk/board/common/src/: bt_uart_bridge.c hci_adapter.c hci_process.c trace_task.c
    ../../../../../vendors/realtek/sdk/amebaZ2/component/common/file_system/ftl/: ftl.c
  group bluetooth/example
    ../../../../../vendors/realtek/sdk/amebaZ2/component/common/bluetooth/realtek/sdk/: bt_example_entry.c
  group bluetooth/example/ble_central
    ../../../../../vendors/realtek/sdk/amebaZ2/component/common/bluetooth/realtek/sdk/example/ble_central/: ble_central_app_main.c ble_central_app_task.c ble_central_at_cmd.c ble_central_client_app.c ble_central_link_mgr.c user_cmd.c
    ../../../../../vendors/realtek/sdk/amebaZ2/component/common/bluetooth/realtek/sdk/src/ble/profile/client/: gcs_client.c
    ../../../../../vendors/realtek/sdk/amebaZ2/component/common/bluetooth/realtek/sdk/src/mcu/module/data_uart_cmd/: user_cmd_parse.c
  group bluetooth/example/ble_peripheral
    ../../../../../vendors/realtek/sdk/amebaZ2/component/common/bluetooth/realtek/sdk/example/ble_peripheral/: app_task.c ble_app_main.c ble_peripheral_at_cmd.c peripheral_app.c
  group bluetooth/example/ble_scatternet
    ../../../../../vendors/realtek/sdk/amebaZ2/component/common/bluetooth/realtek/sdk/example/ble_scatternet/: ble_scatternet_app.c ble_scatternet_app_main.c ble_scatternet_app_task.c ble_scatternet_link_mgr.c ble_scatternet_user_cmd.c
  group bluetooth/example/bt_airsync_config
    ../../../../../vendors/realtek/sdk/amebaZ2/component/common/application/airsync/1.0.4/: airsync_ble_service.c check_endian.c epb.c epb_MmBp.c epb_WristBand.c wechat_airsync_protocol.c
    ../../../../../vendors/realtek/sdk/amebaZ2/component/common/bluetooth/realtek/sdk/example/bt_airsync_config/: bt_airsync_config_app_main.c bt_airsync_config_app_task.c bt_airsync_config_peripheral_app.c
  group bluetooth/example/bt_beacon
    ../../../../../vendors/realtek/sdk/amebaZ2/component/common/bluetooth/realtek/sdk/example/bt_beacon/: bt_beacon_app.c bt_beacon_app_main.c bt_beacon_app_task.c
  group bluetooth/example/bt_config
    ../../../../../vendors/realtek/sdk/amebaZ2/component/common/bluetooth/realtek/sdk/example/bt_config/: bt_config_app_main.c bt_config_app_task.c bt_config_peripheral_app.c bt_config_service.c bt_config_wifi.c
  group bluetooth/example/bt_mesh/mesh_common/cmd
    ../../../../../vendors/realtek/sdk/amebaZ2/component/common/bluetooth/realtek/sdk/example/bt_mesh/lib/cmd/: mesh_cmd.c mesh_data_uart.c mesh_user_cmd_parse.c test_cmd.c
  group bluetooth/example/bt_mesh/mesh_common/common
    ../../../../../vendors/realtek/sdk/amebaZ2/component/common/bluetooth/realtek/sdk/example/bt_mesh/api/: bt_mesh_user_api.c
    ../../../../../vendors/realtek/sdk/amebaZ2/component/common/bluetooth/realtek/sdk/example/bt_mesh/lib/common/: datatrans_app.c ping_app.c
  group bluetooth/example/bt_mesh/mesh_common/model
    ../../../../../vendors/realtek/sdk/amebaZ2/component/common/bluetooth/realtek/sdk/example/bt_mesh/lib/model/realtek/: datatrans_model.c ping_control.c tp_control.c
  group bluetooth/example/bt_mesh/mesh_common/profile
    ../../../../../vendors/realtek/sdk/amebaZ2/component/common/bluetooth/realtek/sdk/example/bt_mesh/lib/profile/: datatrans_service.c
  group bluetooth/example/bt_mesh/mesh_device
    ../../../../../vendors/realtek/sdk/amebaZ2/component/common/bluetooth/realtek/sdk/example/bt_mesh/api/device/: bt_mesh_device_api.c
  group bluetooth/example/bt_mesh/mesh_device/bt_mesh_device_rtk_demo
    ../../../../../vendors/realtek/sdk/amebaZ2/component/common/bluetooth/realtek/sdk/example/bt_mesh_device_rtk_demo/: example_bt_mesh_device_rtk_demo.c
  group bluetooth/example/bt_mesh/mesh_device/common
    ../../../../../vendors/realtek/sdk/amebaZ2/component/common/bluetooth/realtek/sdk/example/bt_mesh/lib/common/: light_server_app.c scene_server_app.c scheduler_server_app.c time_server_app.c
  group bluetooth/example/bt_mesh/mesh_device/device
    ../../../../../vendors/realtek/sdk/amebaZ2/component/common/bluetooth/realtek/sdk/example/bt_mesh/device/: bt_mesh_device_app_main.c bt_mesh_device_app_task.c device_app.c device_cmd.c
  group bluetooth/example/bt_mesh/mesh_device/device_multiple_profile
    ../../../../../vendors/realtek/sdk/amebaZ2/component/common/bluetooth/realtek/sdk/example/bt_mesh_multiple_profile/device_multiple_profile/: bt_mesh_device_multiple_profile_app_main.c bt_mesh_device_multiple_profile_app_task.c device_multiple_profile_app.c device_multiple_profile_cmd.c
  group bluetooth/example/bt_mesh/mesh_device/lib
    ../../../../../vendors/realtek/sdk/amebaZ2/component/common/bluetooth/realtek/sdk/example/bt_mesh/lib/lib/amebaz2/: btmesh_dev.a
  group bluetooth/example/bt_mesh/mesh_device/model
    ../../../../../vendors/realtek/sdk/amebaZ2/component/common/bluetooth/realtek/sdk/example/bt_mesh/lib/model/: delay_execution.c generic_on_off_server.c generic_transition_time.c health_server.c light_ctl_server.c light_ctl_setup_server.c light_ctl_temperature_server.c light_hsl_hue_server.c light_hsl_saturation_server.c light_hsl_server.c light_hsl_setup_server.c light_lightness_server.c light_lightness_setup_server.c light_xyl_server.c light_xyl_setup_server.c scene_server.c scene_setup_server.c scheduler_server.c scheduler_setup_server.c time_server.c time_setup_server.c
  group bluetooth/example/bt_mesh/mesh_device/profile
    ../../../../../vendors/realtek/sdk/amebaZ2/component/common/bluetooth/realtek/sdk/example/bt_mesh/lib/profile/: datatrans_server.c
  group bluetooth/example/bt_mesh/mesh_provisioner
    ../../../../../vendors/realtek/sdk/amebaZ2/component/common/bluetooth/realtek/sdk/example/bt_mesh/api/provisioner/: bt_mesh_provisioner_api.c
  group bluetooth/example/bt_mesh/mesh_provisioner/bt_mesh_provisioner_rtk_demo
    ../../../../../vendors/realtek/sdk/amebaZ2/component/common/bluetooth/realtek/sdk/example/bt_mesh_provisioner_rtk_demo/src/: bt_mesh_app_http_intf.c bt_mesh_app_lib_intf.c bt_mesh_app_list_intf.c bt_mesh_broadcast_demo.c
    ../../../../../vendors/realtek/sdk/amebaZ2/component/common/bluetooth/realtek/sdk/example/bt_mesh_provisioner_rtk_demo/: example_bt_mesh_provisioner_rtk_demo.c
  group bluetooth/example/bt_mesh/mesh_provisioner/cmd
    ../../../../../vendors/realtek/sdk/amebaZ2/component/common/bluetooth/realtek/sdk/example/bt_mesh/lib/cmd/: client_cmd.c
  group bluetooth/example/bt_mesh/mesh_provisioner/common
    ../../../../../vendors/realtek/sdk/amebaZ2/component/common/bluetooth/realtek/sdk/example/bt_mesh/lib/common/: generic_client_app.c light_client_app.c
  group bluetooth/example/bt_mesh/mesh_provisioner/lib
    ../../../../../vendors/realtek/sdk/amebaZ2/component/common/bluetooth/realtek/sdk/example/bt_mesh/lib/lib/amebaz2/: btmesh_prov.a
  group bluetooth/example/bt_mesh/mesh_provisioner/model
    ../../../../../vendors/realtek/sdk/amebaZ2/component/common/bluetooth/realtek/sdk/example/bt_mesh/lib/model/: configuration_client.c generic_battery_client.c generic_default_transition_time_client.c generic_level_client.c generic_location_client.c generic_on_off_client.c generic_power_level_client.c generic_power_on_off_client.c generic_property_client.c health_client.c light_ctl_client.c light_hsl_client.c light_lightness_client.c light_xyl_client.c scene_client.c scheduler_client.c sensor_client.c time_client.c
    ../../../../../vendors/realtek/sdk/amebaZ2/component/common/bluetooth/realtek/sdk/example/bt_mesh/lib/model/realtek/: light_cwrgb_client.c
  group bluetooth/example/bt_mesh/mesh_provisioner/provisioner
    ../../../../../vendors/realtek/sdk/amebaZ2/component/common/bluetooth/realtek/sdk/example/bt_mesh/provisioner/: bt_mesh_provisioner_app_main.c bt_mesh_provisioner_app_task.c provisioner_app.c provisioner_cmd.c
  group bluetooth/example/bt_mesh/mesh_provisioner/provisioner_multiple_profile
    ../../../../../vendors/realtek/sdk/amebaZ2/component/common/bluetooth/realtek/sdk/example/bt_mesh_multiple_profile/provisioner_multiple_profile/: bt_mesh_provisioner_multiple_profile_app_main.c bt_mesh_provisioner_multiple_profile_app_task.c provisioner_multiple_profile_app.c provisioner_multiple_profile_cmd.c
  group cmsis
    ../../../../../vendors/realtek/sdk/amebaZ2/component/soc/realtek/8710c/cmsis/rtl8710c/source/ram_s/: app_start.c
    ../../../../../vendors/realtek/sdk/amebaZ2/component/soc/realtek/8710c/misc/utilities/source/ram/: libc_wrap.c
    ../../../../../vendors/realtek/sdk/amebaZ2/component/soc/realtek/8710c/cmsis/rtl8710c/source/ram/: mpu_config.c sys_irq.c
  group console
    ../../../../../vendors/realtek/sdk/amebaZ2/component/common/api/at_cmd/: atcmd_bt.c atcmd_lwip.c atcmd_mp.c atcmd_mp_ext2.c atcmd_sys.c atcmd_wifi.c log_service.c
    ../../../../../vendors/realtek/sdk/amebaZ2/component/soc/realtek/8710c/app/shell/: cmd_shell.c
    ../../../../../vendors/realtek/sdk/amebaZ2/component/soc/realtek/8710c/app/shell/ram_s/: consol_cmds.c
    ../../../../../vendors/realtek/sdk/amebaZ2/component/soc/realtek/8710c/misc/driver/: rtl_console.c
  group lib
    ../../../../../vendors/realtek/sdk/amebaZ2/component/common/bluetooth/realtek/sdk/board/amebaz2/lib/: btgap.a
    ../../../../../vendors/realtek/sdk/amebaZ2/component/soc/realtek/8710c/fwlib/lib/lib/: hal_pmc.a
    ../../../../../vendors/realtek/sdk/amebaZ2/component/soc/realtek/8710c/misc/bsp/lib/common/IAR/: lib_dct.a lib_eap.a lib_googlenest.a lib_http.a lib_p2p.a lib_soc_is.a lib_websocket.a lib_wlan.a lib_wps.a
  group network/api
    ../../../../../vendors/realtek/sdk/amebaZ2/component/common/api/: lwip_netconf.c
  group network/api/wifi
    ../../../../../vendors/realtek/sdk/amebaZ2/component/common/api/wifi/: wifi_conf.c wifi_ind.c wifi_promisc.c wifi_simple_config.c wifi_util.c
  group network/api/wifi/rtw_wpa_supplicant
    ../../../../../vendors/realtek/sdk/amebaZ2/component/common/api/wifi/rtw_wpa_supplicant/src/crypto/: tls_polarssl.c
    ../../../../../vendors/realtek/sdk/amebaZ2/component/common/api/wifi/rtw_wpa_supplicant/wpa_supplicant/: wifi_eap_config.c wifi_p2p_config.c wifi_wps_config.c
  group network/app
    ../../../../../vendors/realtek/sdk/amebaZ2/component/soc/realtek/8710c/misc/platform/: ota_8710c.c
    ../../../../../vendors/realtek/sdk/amebaZ2/component/common/api/network/src/: ping_test.c wlan_network.c
    ../../../../../vendors/realtek/sdk/amebaZ2/component/common/utilities/: ssl_client.c ssl_client_ext.c tcptest.c
  group network/app/mqtt
    ../../../../../vendors/realtek/sdk/amebaZ2/component/common/application/mqtt/MQTTClient/: MQTTClient.c MQTTFreertos.c
    ../../../../../vendors/realtek/sdk/amebaZ2/component/common/application/mqtt/MQTTPacket/: MQTTConnectClient.c MQTTConnectServer.c MQTTDeserializePublish.c MQTTFormat.c MQTTPacket.c MQTTSerializePublish.c MQTTSubscribeClient.c MQTTSubscribeServer.c MQTTUnsubscribeClient.c MQTTUnsubscribeServer.c
  group network/coap
    ../../../../../vendors/realtek/sdk/amebaZ2/component/common/network/coap/: sn_coap_ameba_port.c sn_coap_builder.c sn_coap_header_check.c sn_coap_parser.c sn_coap_protocol.c
  group network/googlenest
    ../../../../../vendors/realtek/sdk/amebaZ2/component/common/application/google/: google_tls.c
  group network/http
    ../../../../../vendors/realtek/sdk/amebaZ2/component/common/network/httpc/: httpc_tls.c
    ../../../../../vendors/realtek/sdk/amebaZ2/component/common/network/httpd/: httpd_tls.c
  group network/lwip
    ../../../../../vendors/realtek/sdk/amebaZ2/component/common/network/dhcp/: dhcps.c
    ../../../../../vendors/realtek/sdk/amebaZ2/component/common/network/sntp/: sntp.c
  group network/lwip/api
    ../../../../../vendors/realtek/sdk/amebaZ2/component/common/network/lwip/lwip_v2.0.2/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group network/lwip/core
    ../../../../../vendors/realtek/sdk/amebaZ2/component/common/network/lwip/lwip_v2.0.2/src/core/: def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
  group network/lwip/core/ipv4
    ../../../../../vendors/realtek/sdk/amebaZ2/component/common/network/lwip/lwip_v2.0.2/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
  group network/lwip/core/ipv6
    ../../../../../vendors/realtek/sdk/amebaZ2/component/common/network/lwip/lwip_v2.0.2/src/core/ipv6/: dhcp6.c ethip6.c icmp6.c inet6.c ip6.c ip6_addr.c ip6_frag.c mld6.c nd6.c
  group network/lwip/netif
    ../../../../../vendors/realtek/sdk/amebaZ2/component/common/network/lwip/lwip_v2.0.2/src/netif/: ethernet.c
  group network/lwip/port
    ../../../../../vendors/realtek/sdk/amebaZ2/component/common/network/lwip/lwip_v2.0.2/port/realtek/freertos/: ethernetif.c sys_arch.c
    ../../../../../vendors/realtek/sdk/amebaZ2/component/common/drivers/wlan/realtek/src/osdep/: lwip_intf.c
  group network/mdns
    ../../../../../vendors/realtek/sdk/amebaZ2/component/common/network/mDNS/: mDNSPlatform.c
  group network/ssl/mbedtls
    ../../../../../vendors/realtek/sdk/amebaZ2/component/common/network/ssl/mbedtls-2.4.0/library/: aesni.c blowfish.c camellia.c ccm.c certs.c cipher.c cipher_wrap.c cmac.c debug.c entropy.c error.c gcm.c havege.c md.c md2.c md4.c md_wrap.c memory_buffer_alloc.c net_sockets.c padlock.c pkcs11.c pkcs12.c pkcs5.c pkparse.c platform.c ripemd160.c sha256.c ssl_cache.c ssl_ciphersuites.c ssl_cli.c ssl_cookie.c ssl_srv.c ssl_ticket.c ssl_tls.c threading.c timing.c version.c version_features.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509write_crt.c x509write_csr.c xtea.c
  group network/ssl/ssl_ram_map
    ../../../../../vendors/realtek/sdk/amebaZ2/component/common/network/ssl/ssl_ram_map/rom/: rom_ssl_ram_map.c
    ../../../../../vendors/realtek/sdk/amebaZ2/component/common/network/ssl/ssl_func_stubs/: ssl_func_stubs.c
  group network/websocket
    ../../../../../vendors/realtek/sdk/amebaZ2/component/common/network/websocket/: wsclient_tls.c wsserver_tls.c
  group os
    ../../../../../vendors/realtek/sdk/amebaZ2/component/os/freertos/: cmsis_os.c freertos_cb.c freertos_pmu.c freertos_service.c
    ../../../../../vendors/realtek/sdk/amebaZ2/component/os/os_dep/: device_lock.c osdep_service.c
  group os/freertos
    ../../../../../vendors/realtek/sdk/amebaZ2/component/os/freertos/freertos_v10.0.1/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c timers_10.3.0.c
  group os/freertos/portable
    ../../../../../vendors/realtek/sdk/amebaZ2/component/os/freertos/freertos_v10.0.1/Source/portable/MemMang/: heap_5.c
    ../../../../../vendors/realtek/sdk/amebaZ2/component/os/freertos/freertos_v10.0.1/Source/portable/IAR/ARM_RTL8710C/: port.c portasm.s
  group peripheral/api
    ../../../../../vendors/realtek/sdk/amebaZ2/component/common/mbed/targets/hal/rtl8710c/: crypto_api.c dma_api.c efuse_api.c gpio_api.c gpio_irq_api.c i2c_api.c pinmap.c pinmap_common.c port_api.c pwmout_api.c reset_reason_api.c rtc_api.c serial_api.c spdio_api.c spi_api.c sys_api.c timer_api.c us_ticker.c us_ticker_api.c wait_api.c wdt_api.c
  group peripheral/hal
    ../../../../../vendors/realtek/sdk/amebaZ2/component/soc/realtek/8710c/fwlib/source/ram_s/: hal_efuse.c hal_pinmux_nsc.c
    ../../../../../vendors/realtek/sdk/amebaZ2/component/soc/realtek/8710c/fwlib/source/ram/: hal_gdma.c hal_gpio.c hal_misc.c hal_uart.c
    ../../../../../vendors/realtek/sdk/amebaZ2/component/soc/realtek/8710c/fwlib/source/ram_ns/: hal_i2c.c hal_pwm.c hal_sdio_dev.c hal_ssi.c
  group peripheral/wlan
    ../../../../../vendors/realtek/sdk/amebaZ2/component/common/drivers/wlan/realtek/src/core/option/: rtw_opt_power_by_rate.c rtw_opt_power_limit.c rtw_opt_skbuf.c
  group user
    ../../../../../vendors/realtek/sdk/amebaZ2/project/realtek_amebaz2_v0_example/src/: main.c
  group utilities
    ../../../../../vendors/realtek/sdk/amebaZ2/component/common/utilities/: cJSON.c http_client.c xml.c
  group utilities/example
    ../../../../../vendors/realtek/sdk/amebaZ2/component/common/example/amazon_afqp_tests/: example_amazon_afqp_tests.c
    ../../../../../vendors/realtek/sdk/amebaZ2/component/common/example/amazon_freertos/: example_amazon_freertos.c
    ../../../../../vendors/realtek/sdk/amebaZ2/component/common/example/bcast/: example_bcast.c
    ../../../../../vendors/realtek/sdk/amebaZ2/component/common/example/cJSON/: example_cJSON.c
    ../../../../../vendors/realtek/sdk/amebaZ2/component/common/example/coap/: example_coap.c
    ../../../../../vendors/realtek/sdk/amebaZ2/component/common/example/coap_client/: example_coap_client.c
    ../../../../../vendors/realtek/sdk/amebaZ2/component/common/example/coap_server/: example_coap_server.c
    ../../../../../vendors/realtek/sdk/amebaZ2/component/common/example/dct/: example_dct.c
    ../../../../../vendors/realtek/sdk/amebaZ2/component/common/example/: example_entry.c
    ../../../../../vendors/realtek/sdk/amebaZ2/component/common/example/fatfs/: example_fatfs.c
    ../../../../../vendors/realtek/sdk/amebaZ2/component/common/example/get_beacon_frame/: example_get_beacon_frame.c
    ../../../../../vendors/realtek/sdk/amebaZ2/component/common/example/high_load_memory_use/: example_high_load_memory_use.c
    ../../../../../vendors/realtek/sdk/amebaZ2/component/common/example/http_client/: example_http_client.c
    ../../../../../vendors/realtek/sdk/amebaZ2/component/common/example/http_download/: example_http_download.c
    ../../../../../vendors/realtek/sdk/amebaZ2/component/common/example/httpc/: example_httpc.c
    ../../../../../vendors/realtek/sdk/amebaZ2/component/common/example/httpd/: example_httpd.c
    ../../../../../vendors/realtek/sdk/amebaZ2/component/common/example/mcast/: example_mcast.c
    ../../../../../vendors/realtek/sdk/amebaZ2/component/common/example/mqtt/: example_mqtt.c
    ../../../../../vendors/realtek/sdk/amebaZ2/component/common/example/nonblock_connect/: example_nonblock_connect.c
    ../../../../../vendors/realtek/sdk/amebaZ2/component/common/example/ota_http/: example_ota_http.c
    ../../../../../vendors/realtek/sdk/amebaZ2/component/common/example/rarp/: example_rarp.c
    ../../../../../vendors/realtek/sdk/amebaZ2/component/common/example/secure_boot/: example_secure_boot.c
    ../../../../../vendors/realtek/sdk/amebaZ2/component/common/example/sntp_showtime/: example_sntp_showtime.c
    ../../../../../vendors/realtek/sdk/amebaZ2/component/common/example/socket_select/: example_socket_select.c
    ../../../../../vendors/realtek/sdk/amebaZ2/component/common/example/socket_tcp_trx/: example_socket_tcp_trx_1.c example_socket_tcp_trx_2.c
    ../../../../../vendors/realtek/sdk/amebaZ2/component/common/example/ssl_download/: example_ssl_download.c
    ../../../../../vendors/realtek/sdk/amebaZ2/component/common/example/ssl_server/: example_ssl_server.c
    ../../../../../vendors/realtek/sdk/amebaZ2/component/common/example/tcp_keepalive/: example_tcp_keepalive.c
    ../../../../../vendors/realtek/sdk/amebaZ2/component/common/example/uart_atcmd/: example_uart_atcmd.c
    ../../../../../vendors/realtek/sdk/amebaZ2/component/common/example/wifi_mac_monitor/: example_wifi_mac_monitor.c
    ../../../../../vendors/realtek/sdk/amebaZ2/component/common/example/wifi_roaming/: example_wifi_roaming.c
    ../../../../../vendors/realtek/sdk/amebaZ2/component/common/example/wlan_fast_connect/: example_wlan_fast_connect.c
    ../../../../../vendors/realtek/sdk/amebaZ2/component/common/example/wlan_scenario/: example_wlan_scenario.c
    ../../../../../vendors/realtek/sdk/amebaZ2/component/common/example/websocket_client/: example_wsclient.c
    ../../../../../vendors/realtek/sdk/amebaZ2/component/common/example/xml/: example_xml.c
  group utilities/FatFs/disk_if
    ../../../../../vendors/realtek/sdk/amebaZ2/component/common/file_system/fatfs/disk_if/src/: sdcard.c usbdisk.c
    ../../../../../vendors/realtek/sdk/amebaZ2/component/common/drivers/sdio/realtek/sdio_host/src/: sdio_combine.c
  group utilities/FatFs/fatfs_ext
    ../../../../../vendors/realtek/sdk/amebaZ2/component/common/file_system/fatfs/fatfs_ext/src/: ff_driver.c
  group utilities/FatFs/r0.10c
    ../../../../../vendors/realtek/sdk/amebaZ2/component/common/file_system/fatfs/r0.10c/src/: diskio.c ff.c
  group utilities/FatFs/r0.10c/option
    ../../../../../vendors/realtek/sdk/amebaZ2/component/common/file_system/fatfs/r0.10c/src/option/: ccsbcs.c
